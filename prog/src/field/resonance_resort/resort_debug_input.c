//======================================================================
/**
 * @file    resort_debug_input.c
 * @brief   デバッグ入力
 * @author  Toru=Nagihashi    tayaさん、saitoさんのソースを参考に作成
 * @data    10/06/13
 */
//======================================================================

#ifdef PM_DEBUG

#include <gflib.h>
//#include <skb.h>
#include "system/main.h"
#include "print/printsys.h"
#include "print/str_tool.h"
#include "poke_tool/monsno_def.h"
#include "../fieldmap.h"
#include "../event_fieldmap_control.h"

#include "app/research_radar/question_id.h"
#include "app/research_radar/answer_id.h"

#include "font/font.naix"
#include "arc_def.h"
#include "message.naix"
#include "debug_message.naix"
#include "msg/debug/msg_debug_resort.h"
#include "arc/script_message.naix"
#include "msg/script/msg_resort_scr.h"
#include "msg/debug/msg_debug_resort2.h"
#include "savedata/resonance_resort_sv.h"
#include "resort_debug_input.h"
#include "resort_shop.h"
#include "resort_binary.h"
#include "resort_map.h"
#include "net_app/union/union_beacon_tool.h"
#include "resort_debug_inline.h"
#include "resort_debug.h"

#define PROC_HEAP_SIZE  (0x40000)
#define PRINT_FRAME (GFL_BG_FRAME1_M)
#define TEXT_FRAME (GFL_BG_FRAME0_S)
#define PRINT_PALIDX  (0)
#define LINE_HEIGHT (11)

#define LINE_MARGIN (1)
#define LINE_DIFFER (LINE_HEIGHT + LINE_MARGIN)
#define STRBUF_LEN  (64)
#define TOUCH_H   (8)
#define NUMINPUT_DISIT_MAX (32)
#define NUMBOX_MARGIN (3)
#define NUMBOX_CHAR_WIDTH (8)
#define SKB_PALIDX1 (1)
#define SKB_PALIDX2 (2)

#define INPUT_VALUE_MAX (0xffffffff)
#define CAPTION_NONE    (0xffffffff)

enum {
  STR_POS_X = 0,
  STR_LINE0_POS_Y  = LINE_DIFFER*0,
  STR_LINE1_POS_Y  = LINE_DIFFER*1,
  STR_LINE2_POS_Y  = LINE_DIFFER*2,
  STR_LINE3_POS_Y  = LINE_DIFFER*3,
  STR_LINE4_POS_Y  = LINE_DIFFER*4,
  STR_LINE5_POS_Y  = LINE_DIFFER*5,
  STR_LINE6_POS_Y  = LINE_DIFFER*6,
  STR_LINE7_POS_Y  = LINE_DIFFER*7,
  STR_LINE8_POS_Y  = LINE_DIFFER*8,
  STR_LINE9_POS_Y  = LINE_DIFFER*9,
  STR_LINE10_POS_Y  = LINE_DIFFER*10,
  STR_LINE11_POS_Y  = LINE_DIFFER*11,
  STR_LINE12_POS_Y  = LINE_DIFFER*12,
  STR_LINE13_POS_Y  = LINE_DIFFER*13,
  STR_LINE14_POS_Y  = LINE_DIFFER*14,
  STR_LINE15_POS_Y  = LINE_DIFFER*15,
};

typedef enum {
  SEQ_DRAW_CAPTION = 0,
  SEQ_DRAW_BOX,
  SEQ_WAIT_CTRL,
  SEQ_INPUT_STR,
  SEQ_INPUT_NUM,
  SEQ_REDRAW,

}MAIN_CTRL_SEQ;

typedef enum {
  STR_TYPE_STR,      ///< 入力対応文字列（文字列から導かれるインデックスを保存する場合）
  STR_TYPE_NUM,      ///< 入力対応数値  arg =max arg2 =min
  STR_TYPE_SWITCH,   ///< タッチ対応トグルスイッチ
  STR_TYPE_EDITSTR,  ///< 入力対応文字列（文字列自体を保存する場合）
  STR_TYPE_FIXNUM,    ///< 表示するだけの数値
  STR_TYPE_BUTTON,    ///< アクションがあるもの arg=strID arg2=Func

  STR_TYPE_CAPTION,   ///< 文字列のみ
  STR_TYPE_BIT,       ///< bit操作　arg=ビットの数
}STR_TYPE;

typedef enum {
  //初期ページ
  EDITBOX_ID_FIRST_PEOPLE,
  EDITBOX_ID_FIRST_ADD_BTN,
  EDITBOX_ID_FIRST_CHANGE_BTN,
  EDITBOX_ID_FIRST_CHANGE_NUM,

  //街ページ
  EDITBOX_ID_CITY_LV,
  EDITBOX_ID_CITY_EXP,
  EDITBOX_ID_CITY_TEX,
  EDITBOX_ID_CITY_FUN_DAY,
  EDITBOX_ID_IS_TUTORIAL,
  EDITBOX_ID_IS_EV_PRIZE1,
  EDITBOX_ID_IS_EV_PRIZE2,
  EDITBOX_ID_IS_EV_PRIZE3,
  EDITBOX_ID_IS_EV_PRIZE4,
  EDITBOX_ID_IS_EV_PRIZE5,
  EDITBOX_ID_IS_EV_PRIZE6,
  EDITBOX_ID_IS_PRIZE1,
  EDITBOX_ID_IS_PRIZE2,
  EDITBOX_ID_IS_PRIZE3,
  EDITBOX_ID_IS_PRIZE4,
  EDITBOX_ID_IS_PRIZE5,
  EDITBOX_ID_IS_PRIZE6,
  EDITBOX_ID_IS_CELEB_APPEAL,
  EDITBOX_ID_IS_CELEB_TRADE,

  //お店配置
  EDITBOX_ID_SHOP_ID_00,
  EDITBOX_ID_SHOP_KIND_00,
  EDITBOX_ID_SHOP_LV_00,
  EDITBOX_ID_SHOP_EXP_00,
  EDITBOX_ID_SHOP_TYPE_00,
  EDITBOX_ID_SHOP_ID_01,
  EDITBOX_ID_SHOP_KIND_01,
  EDITBOX_ID_SHOP_LV_01,
  EDITBOX_ID_SHOP_EXP_01,
  EDITBOX_ID_SHOP_TYPE_01,
  EDITBOX_ID_SHOP_ID_02,
  EDITBOX_ID_SHOP_KIND_02,
  EDITBOX_ID_SHOP_LV_02,
  EDITBOX_ID_SHOP_EXP_02,
  EDITBOX_ID_SHOP_TYPE_02,
  EDITBOX_ID_SHOP_ID_03,
  EDITBOX_ID_SHOP_KIND_03,
  EDITBOX_ID_SHOP_LV_03,
  EDITBOX_ID_SHOP_EXP_03,
  EDITBOX_ID_SHOP_TYPE_03,
  EDITBOX_ID_SHOP_ID_04,
  EDITBOX_ID_SHOP_KIND_04,
  EDITBOX_ID_SHOP_LV_04,
  EDITBOX_ID_SHOP_EXP_04,
  EDITBOX_ID_SHOP_TYPE_04,
  EDITBOX_ID_SHOP_ID_05,
  EDITBOX_ID_SHOP_KIND_05,
  EDITBOX_ID_SHOP_LV_05,
  EDITBOX_ID_SHOP_EXP_05,
  EDITBOX_ID_SHOP_TYPE_05,
  EDITBOX_ID_SHOP_ID_06,
  EDITBOX_ID_SHOP_KIND_06,
  EDITBOX_ID_SHOP_LV_06,
  EDITBOX_ID_SHOP_EXP_06,
  EDITBOX_ID_SHOP_TYPE_06,
  EDITBOX_ID_SHOP_ID_07,
  EDITBOX_ID_SHOP_KIND_07,
  EDITBOX_ID_SHOP_LV_07,
  EDITBOX_ID_SHOP_EXP_07,
  EDITBOX_ID_SHOP_TYPE_07,

  //住民基礎データ
  EDITBOX_ID_BASIC_TRAINERID,
  EDITBOX_ID_BASIC_CONTRY,
  EDITBOX_ID_BASIC_AREA,
  EDITBOX_ID_BASIC_LANG,
  EDITBOX_ID_BASIC_VER,
  EDITBOX_ID_BASIC_VIEW,
  EDITBOX_ID_BASIC_SEX,
  EDITBOX_ID_BASIC_PLAY_HOUR,
  EDITBOX_ID_BASIC_PLAY_MIN,

  //住民準基本データ
  EDITBOX_ID_SUB_SPECIAL,
  EDITBOX_ID_SUB_WANTJOB,
  EDITBOX_ID_SUB_CITYLV,

  //住民内部データ
  EDITBOX_ID_RESI_PRESENT_ID,
  EDITBOX_ID_RESI_MEET_YEAR,
  EDITBOX_ID_RESI_MEET_MONTH,
  EDITBOX_ID_RESI_MEET_DAY,
  EDITBOX_ID_RESI_MEET_HOUR,
  EDITBOX_ID_RESI_MEET_MIN,
  EDITBOX_ID_RESI_COMM_ID,
  EDITBOX_ID_RESI_MERGE,
  EDITBOX_ID_RESI_KEEP,
  EDITBOX_ID_RESI_LV,
  EDITBOX_ID_RESI_EXP,
  EDITBOX_ID_RESI_EV_WK_00,
  EDITBOX_ID_RESI_EV_WK_01,
  EDITBOX_ID_RESI_EV_BIT,
  EDITBOX_ID_RESI_INSTITUTION_ID,
  EDITBOX_ID_RESI_EXTEND_BIT,
  EDITBOX_ID_RESI_PEOPLE_ID,
  EDITBOX_ID_RESI_PLACE_ID,
  EDITBOX_ID_RESI_KOSEI,
  EDITBOX_ID_RESI_TYPE,
  EDITBOX_ID_RESI_UPDATE,

  //住民拡張１データ
  EDITBOX_ID_EXT1_MEDAL_ID,
  EDITBOX_ID_EXT1_MEDAL_YEAR,
  EDITBOX_ID_EXT1_MEDAL_MONTH,
  EDITBOX_ID_EXT1_MEDAL_DAY,
  EDITBOX_ID_EXT1_MEDAL_NUM,
  //住民拡張２データ
  EDITBOX_ID_EXT2_RANK_00,
  EDITBOX_ID_EXT2_RANK_01,
  EDITBOX_ID_EXT2_RANK_02,
  EDITBOX_ID_EXT2_RANK_03,
  //住民拡張３データ
  EDITBOX_ID_EXT3_RANK_04,
  EDITBOX_ID_EXT3_RANK_05,
  EDITBOX_ID_EXT3_RANK_06,
  EDITBOX_ID_EXT3_RANK_07,
  //住民拡張４データ
  EDITBOX_ID_EXT4_GOSSIP_00,
  EDITBOX_ID_EXT4_GOSSIP_01,
  EDITBOX_ID_EXT4_GOSSIP_02,
  EDITBOX_ID_EXT4_GOSSIP_03,
  EDITBOX_ID_EXT4_GOSSIP_04,
  EDITBOX_ID_EXT4_GOSSIP_05,
  EDITBOX_ID_EXT4_GOSSIP_06,
  EDITBOX_ID_EXT4_GOSSIP_07,
  EDITBOX_ID_EXT4_GOSSIP_08,
  EDITBOX_ID_EXT4_GOSSIP_09,
  EDITBOX_ID_EXT4_GOSSIP_10,
  EDITBOX_ID_EXT4_GOSSIP_11,
  EDITBOX_ID_EXT4_GOSSIP_12,
  EDITBOX_ID_EXT4_GOSSIP_13,
  EDITBOX_ID_EXT4_GOSSIP_14,
  EDITBOX_ID_EXT4_GOSSIP_15,
  //住民拡張５データ
  EDITBOX_ID_EXT5_MONSNO,
  EDITBOX_ID_EXT5_FORM,
  EDITBOX_ID_EXT5_SEX,
  EDITBOX_ID_EXT5_RARE,
  EDITBOX_ID_EXT5_TOKUSEI,
  EDITBOX_ID_EXT5_WAZA_00,
  EDITBOX_ID_EXT5_WAZA_01,
  EDITBOX_ID_EXT5_WAZA_02,
  EDITBOX_ID_EXT5_WAZA_03,
  EDITBOX_ID_EXT5_ITEM,
  //住民拡張６データ
  EDITBOX_ID_EXT6_MONSNO,
  EDITBOX_ID_EXT6_FORM,
  EDITBOX_ID_EXT6_SEX,
  EDITBOX_ID_EXT6_RARE,
  EDITBOX_ID_EXT6_TOKUSEI,
  EDITBOX_ID_EXT6_WAZA_00,
  EDITBOX_ID_EXT6_WAZA_01,
  EDITBOX_ID_EXT6_WAZA_02,
  EDITBOX_ID_EXT6_WAZA_03,
  EDITBOX_ID_EXT6_ITEM,
  //住民拡張７データ
  EDITBOX_ID_EXT7_MONSNO,
  EDITBOX_ID_EXT7_FORM,
  EDITBOX_ID_EXT7_SEX,
  EDITBOX_ID_EXT7_RARE,
  EDITBOX_ID_EXT7_TOKUSEI,
  EDITBOX_ID_EXT7_WAZA_00,
  EDITBOX_ID_EXT7_WAZA_01,
  EDITBOX_ID_EXT7_WAZA_02,
  EDITBOX_ID_EXT7_WAZA_03,
  EDITBOX_ID_EXT7_ITEM,
  //住民拡張８データ
  EDITBOX_ID_EXT8_RECORD_00,
  EDITBOX_ID_EXT8_RECORD_01,
  EDITBOX_ID_EXT8_RECORD_02,
  EDITBOX_ID_EXT8_RECORD_03,
  EDITBOX_ID_EXT8_RECORD_YEAR_00,
  EDITBOX_ID_EXT8_RECORD_YEAR_01,
  EDITBOX_ID_EXT8_RECORD_YEAR_02,
  EDITBOX_ID_EXT8_RECORD_YEAR_03,
  EDITBOX_ID_EXT8_RECORD_MONTH_00,
  EDITBOX_ID_EXT8_RECORD_MONTH_01,
  EDITBOX_ID_EXT8_RECORD_MONTH_02,
  EDITBOX_ID_EXT8_RECORD_MONTH_03,
  EDITBOX_ID_EXT8_RECORD_DAY_00,
  EDITBOX_ID_EXT8_RECORD_DAY_01,
  EDITBOX_ID_EXT8_RECORD_DAY_02,
  EDITBOX_ID_EXT8_RECORD_DAY_03,

  //デバッグフラグ
  EDITBOX_ID_FLAG_00,
  EDITBOX_ID_FLAG_01,
  EDITBOX_ID_FLAG_02,
  EDITBOX_ID_FLAG_03,
  EDITBOX_ID_FLAG_04,
  EDITBOX_ID_FLAG_05,
  EDITBOX_ID_FLAG_06,
  EDITBOX_ID_WORK_00,
  EDITBOX_ID_WORK_01,

  EDITBOX_ID_MAX,
  //文字列の場合は以下を使う

  EDITBOX_ID_CITY_CITYNAME   = EDITBOX_ID_MAX,
  EDITBOX_ID_CITY_AUTHERNAME,

  EDITBOX_ID_BASIC_NAME,
  EDITBOX_ID_BASIC_INTRODUCTION,
  EDITBOX_ID_EXT6_PHRASE,

  EDITBOX_ID_ALL_MAX,
  EDITBOX_ID_STR_MAX  = EDITBOX_ID_ALL_MAX - EDITBOX_ID_MAX,

}EDITBOX_ID;

enum {
  COLIDX_BLACK=1,
  COLIDX_GRAY,
  COLIDX_RED_D,
  COLIDX_RED_L,
  COLIDX_BLUE_D,
  COLIDX_BLUE_L,
  COLIDX_YELLOW_D,
  COLIDX_YELLOW_L,
  COLIDX_GREEN_D,
  COLIDX_GREEN_L,
  COLIDX_ORANGE_D,
  COLIDX_ORANGE_L,
  COLIDX_PINK_D,
  COLIDX_PINK_L,
  COLIDX_WHITE,
};

typedef enum
{
  DATA_MODIRY_TYPE_ADD,     //追加
  DATA_MODIRY_TYPE_CHANGE,  //修正
}DATA_MODIFY_TYPE;

typedef enum
{
  NUMINPUT_TYPE_DECIMAL,
  NUMINPUT_TYPE_BIT,
}NUMINPUT_TYPE;

typedef struct _DEBUG_INPUT_WORK DEBUG_INPUT_WORK;

typedef struct {
  STR_TYPE  Type; //ボタンタイプ
  int  StrID;     //描画する文字
  u8   PosX;      //位置X
  u8   PosY;      //位置Y

  u8   TouchX;    //タッチX
  u8   TouchY;    //タッチY
  u8   TouchW;    //タッチ幅
  u8   TouchH;    //タッチ高さ

  u32  arg;       //ボタンタイプ別の引数１
  u32  arg2;      //ボタンタイプ別の引数２
  u32   editBoxID;  //このウィンドウがどのボックスに依存しているか
}STR_PARAM;

//1画面の情報
typedef struct
{
  const STR_PARAM*  strParams;
  u32   len;
} STR_PARAM_DISPLAY;

//画面が複数繋がってページとなる
//ページ読み込み、ページ開放の際にデータを取得、設定する関数も入れる
typedef struct
{
  const STR_PARAM_DISPLAY * display;
  u32 len;
  void (*StoreData)( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv );
  BOOL (*ReStoreData)( RESONANCE_RESORT_SV *p_resort_sv, const DEBUG_INPUT_WORK *cp_wk );
  BOOL (*PushCallback)( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv, u32 boxID );
} STR_PARAM_PAGE;

//各ページの縦のつながり（階層）
typedef struct _STR_PARAM_PAGE_DATA
{
  const STR_PARAM_PAGE *cp_now_page;
  s32 page;
  struct _STR_PARAM_PAGE_DATA *p_prev;
} STR_PARAM_PAGE_STACK;

//--------------------------------------------------------------
/**
 *  数値入力ワーク
 */
//--------------------------------------------------------------
typedef struct {
  GFL_BMPWIN*   Win;
  GFL_BMP_DATA* Bmp;
  GFL_FONT*     Font;
  STRBUF*       Buf;
  PRINT_UTIL*   PrintUtil;
  PRINT_QUE*    PrintQue;
  const STR_PARAM* Param;

  u32  Num;
  u32  Disit;
  u32  NumMax;
  u32  NumMin;
  u8   Draw_ox;
  u8   ColorDefBg;
  u8   ColorCurBg;
  u8   ColorLetter;

  s8   NumAry[ NUMINPUT_DISIT_MAX ];
  u8   CurDisit;
  u32  DispNumWork;

  NUMINPUT_TYPE type;
}NUMINPUT_WORK;

//--------------------------------------------------------------
/**
 *  入力補完ワーク
 */
//--------------------------------------------------------------
typedef struct {
  GFL_SKB*      skb;
  GFL_MSGDATA*  msg;
  STRBUF*       buf;
  STRBUF*       subword;
  STRBUF*       fullword;
  int           index;
  int           search_first_index;
  int           searchingFlag;
}COMP_SKB_WORK;

//-------------------------------------
///	メインワーク
//=====================================
struct _DEBUG_INPUT_WORK
{

  GFL_BMPWIN*     Win;
  GFL_BMP_DATA*   Bmp;
  GFL_FONT*       Font;
  GFL_MSGDATA*    MsgData;
  STRBUF*         StrBuf;
  PRINT_QUE*      PrintQue;
  PRINT_UTIL      PrintUtil;
  GFL_SKB*        skb;

  int             BoxIdx;
  u32             BoxValue[ EDITBOX_ID_MAX ];

  HEAPID  HeapID;
  MAIN_CTRL_SEQ      Seq;

  COMP_SKB_WORK   comp;
  GFL_SKB_SETUP   skbSetup;
  NUMINPUT_WORK   NumInput;
  
  STRBUF*         BoxStrBuf[EDITBOX_ID_STR_MAX];


  STR_PARAM_PAGE_STACK *p_pageData;

  BOOL            touch_prev_flag;
  RESONANCE_RESORT_SV *p_resort_sv;
  DATA_MODIFY_TYPE  modify_type;

  RESORT_BINARY_SHOP  *p_shop;
  GAMEDATA *p_gamedata;
};


extern void RESORT_RESIDENT_DATA_ConvertRecv( RESORT_RESIDENT_DATA *p_wk, const RESORT_RECV_DATA *cp_recv, const RESORT_BINARY_SHOP *cp_shop, u16 peopleID, u16 placeID );

//STR_TYPE_BUTTONのarg2に指定するコールバック
typedef void (*ButtonAction_Callback)( DEBUG_INPUT_WORK *wk, const STR_PARAM *StrParam );
static void ButtonAction_First_Add( DEBUG_INPUT_WORK *wk, const STR_PARAM *StrParam );
static void ButtonAction_First_Change( DEBUG_INPUT_WORK *wk, const STR_PARAM *StrParam );

//STR_PARAM_PAGEのStore,Restore関数
static void City_StoreData( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv );
static BOOL City_ReStoreData( RESONANCE_RESORT_SV *p_resort_sv, const DEBUG_INPUT_WORK *cp_wk );

static void Resident_StoreData( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv );
static BOOL Resident_ReStoreData( RESONANCE_RESORT_SV *p_resort_sv, const DEBUG_INPUT_WORK *cp_wk );

static void Tourist_StoreData( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv );
static BOOL Tourist_ReStoreData( RESONANCE_RESORT_SV *p_resort_sv, const DEBUG_INPUT_WORK *cp_wk );

static void Owner_StoreData( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv );
static BOOL Owner_ReStoreData( RESONANCE_RESORT_SV *p_resort_sv, const DEBUG_INPUT_WORK *cp_wk );

static void ShopPos_StoreData( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv );
static BOOL ShopPos_ReStoreData( RESONANCE_RESORT_SV *p_resort_sv, const DEBUG_INPUT_WORK *cp_wk );
static BOOL ShopPos_PushCallback( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv, u32 boxID );

static void DebugFlag_StoreData( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv );
static BOOL DebugFlag_ReStoreData( RESONANCE_RESORT_SV *p_resort_sv, const DEBUG_INPUT_WORK *cp_wk );
//-------------------------------------
///	データ
//=====================================
//初期ページ
static const STR_PARAM StrParamsFirst[] =
{
  //操作するデータ方法を選んでください
  {STR_TYPE_CAPTION, RESORT_DATA_17,  STR_POS_X, STR_LINE0_POS_Y,
    0,0,0,0,
    0,0,0 },

  //何を操作するか
  {STR_TYPE_SWITCH, RESORT_DATA_16,  STR_POS_X, STR_LINE2_POS_Y,
    8*8,STR_LINE2_POS_Y,12*8,TOUCH_H,
    PEOPLE_00,6,EDITBOX_ID_FIRST_PEOPLE },

  //追加ボタン
  {STR_TYPE_BUTTON, CAPTION_NONE,  STR_POS_X, STR_LINE4_POS_Y,
    8,STR_LINE4_POS_Y,9*8,TOUCH_H,
    RESORT_DATA_18,(u32)ButtonAction_First_Add,EDITBOX_ID_FIRST_ADD_BTN },

  //変更
  {STR_TYPE_BUTTON, CAPTION_NONE,  STR_POS_X, STR_LINE6_POS_Y,
    8,STR_LINE6_POS_Y,9*8,TOUCH_H,
    RESORT_DATA_19,(u32)ButtonAction_First_Change,EDITBOX_ID_FIRST_CHANGE_BTN },
  
  //変更する番号
  {STR_TYPE_NUM, CAPTION_NONE,  STR_POS_X, STR_LINE6_POS_Y,
    10*8,STR_LINE6_POS_Y,4*8,TOUCH_H,
    32,0,EDITBOX_ID_FIRST_CHANGE_NUM },
};

//街ページ
static const STR_PARAM StrParamsCity[] =
{
  //街情報
  {STR_TYPE_CAPTION, RESORT_DATA_84,  STR_POS_X, STR_LINE0_POS_Y,
    0,0,0,0,
    0,0,0 },
  //街名
  {STR_TYPE_EDITSTR, RESORT_DATA_85,  STR_POS_X, STR_LINE2_POS_Y,
    40,STR_LINE2_POS_Y,12*10,TOUCH_H,
    0,0,EDITBOX_ID_CITY_CITYNAME},
  //持ち主名
  {STR_TYPE_EDITSTR, RESORT_DATA_86,  STR_POS_X, STR_LINE3_POS_Y,
    40,STR_LINE3_POS_Y,12*10,TOUCH_H,
    0,0,EDITBOX_ID_CITY_AUTHERNAME},
  //状態
  {STR_TYPE_SWITCH, RESORT_DATA_87,  STR_POS_X, STR_LINE4_POS_Y,
    70,STR_LINE4_POS_Y,10*8,TOUCH_H,
    YESNO_00, 2,EDITBOX_ID_IS_TUTORIAL },
  //LV
  {STR_TYPE_NUM, RESORT_DATA_88,  STR_POS_X, STR_LINE5_POS_Y,
    16,STR_LINE5_POS_Y,4*8,TOUCH_H,
    255,0,EDITBOX_ID_CITY_LV },
  //経験値
  {STR_TYPE_NUM, RESORT_DATA_89, 60+STR_POS_X, STR_LINE5_POS_Y,
    60+16,STR_LINE5_POS_Y,4*8,TOUCH_H,
    65535,0,EDITBOX_ID_CITY_EXP },
  //テクスチャ
  {STR_TYPE_NUM, RESORT_DATA_90,  STR_POS_X, STR_LINE6_POS_Y,
    32,STR_LINE6_POS_Y,4*8,TOUCH_H,
    4,0,EDITBOX_ID_CITY_TEX },
  //１日ファンフラグ
  {STR_TYPE_SWITCH, RESORT_DATA_91,  80+STR_POS_X, STR_LINE6_POS_Y,
    160,STR_LINE6_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_CITY_FUN_DAY },

  //ご褒美　秘書３
  {STR_TYPE_SWITCH, RESORT_DATA_101,  STR_POS_X, STR_LINE7_POS_Y,
    60,STR_LINE7_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_IS_PRIZE1 },
  {STR_TYPE_SWITCH, CAPTION_NONE,  STR_POS_X, STR_LINE7_POS_Y,
    60+16,STR_LINE7_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_IS_EV_PRIZE1 },

  //ご褒美　秘書４
  {STR_TYPE_SWITCH, RESORT_DATA_102,  128+STR_POS_X, STR_LINE7_POS_Y,
    128+60,STR_LINE7_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_IS_PRIZE2 },
  {STR_TYPE_SWITCH, CAPTION_NONE,  STR_POS_X, STR_LINE7_POS_Y,
    128+60+16,STR_LINE7_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_IS_EV_PRIZE2 },

  //ご褒美　街名
  {STR_TYPE_SWITCH, RESORT_DATA_103,  STR_POS_X, STR_LINE8_POS_Y,
    60,STR_LINE8_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_IS_PRIZE3 },
  {STR_TYPE_SWITCH, CAPTION_NONE,  STR_POS_X, STR_LINE8_POS_Y,
    60+16,STR_LINE8_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_IS_EV_PRIZE3 },

  //ご褒美　ネオン
  {STR_TYPE_SWITCH, RESORT_DATA_104,  128+STR_POS_X, STR_LINE8_POS_Y,
    128+60,STR_LINE8_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_IS_PRIZE4 },
  {STR_TYPE_SWITCH, CAPTION_NONE,  STR_POS_X, STR_LINE8_POS_Y,
    128+60+16,STR_LINE8_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_IS_EV_PRIZE4 },

  //ご褒美　スカウト
  {STR_TYPE_SWITCH, RESORT_DATA_105,  STR_POS_X, STR_LINE9_POS_Y,
    60,STR_LINE9_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_IS_PRIZE5 },
  {STR_TYPE_SWITCH, CAPTION_NONE,  STR_POS_X, STR_LINE9_POS_Y,
    60+16,STR_LINE9_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_IS_EV_PRIZE5 },

  //ご褒美　解放
  {STR_TYPE_SWITCH, RESORT_DATA_108,  128+STR_POS_X, STR_LINE9_POS_Y,
    128+60,STR_LINE9_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_IS_PRIZE6 },
  {STR_TYPE_SWITCH, CAPTION_NONE,  STR_POS_X, STR_LINE9_POS_Y,
    128+60+16,STR_LINE9_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_IS_EV_PRIZE6 },

  //セレブ１日出現
  {STR_TYPE_SWITCH, RESORT_DATA_106,  STR_POS_X, STR_LINE10_POS_Y,
    60,STR_LINE10_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_IS_CELEB_APPEAL },

  //セレブ１日１回交換
  {STR_TYPE_SWITCH, RESORT_DATA_106, 128+STR_POS_X, STR_LINE10_POS_Y,
    128+60,STR_LINE10_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_IS_CELEB_TRADE },
};

//住民基本データ
static const STR_PARAM StrParamsResidentBasic[] = 
{
  //住民基礎情報
  {STR_TYPE_CAPTION, RESORT_DATA_00,  STR_POS_X, STR_LINE0_POS_Y,
    0,0,0,0,
    0,0,0 },
  //なまえ
  {STR_TYPE_EDITSTR, RESORT_DATA_01,  STR_POS_X, STR_LINE1_POS_Y,
    4*8,STR_LINE1_POS_Y,8*8,TOUCH_H,
    0,0,EDITBOX_ID_BASIC_NAME },
  //トレーナーID
  {STR_TYPE_NUM, RESORT_DATA_02,  13*8, STR_LINE1_POS_Y,
    14*8+6*8,STR_LINE1_POS_Y,8*8,TOUCH_H,
    0xFFFFFFFF,0,EDITBOX_ID_BASIC_TRAINERID },
  //挨拶
  {STR_TYPE_EDITSTR, RESORT_DATA_15,  STR_POS_X, STR_LINE2_POS_Y,
    8*8,STR_LINE2_POS_Y,12*8,TOUCH_H,
    0,0,EDITBOX_ID_BASIC_INTRODUCTION },
  //国
  {STR_TYPE_STR, RESORT_DATA_03,  STR_POS_X, STR_LINE4_POS_Y,
    3*8,STR_LINE4_POS_Y,12*8,TOUCH_H,
    NARC_message_wifi_place_msg_world_dat,0,EDITBOX_ID_BASIC_CONTRY },
  //地域
  {STR_TYPE_NUM, RESORT_DATA_04,  15*8, STR_LINE4_POS_Y,
    19*8,STR_LINE4_POS_Y,12*8,TOUCH_H,
    255,0,EDITBOX_ID_BASIC_AREA },
  //言語
  {STR_TYPE_SWITCH, RESORT_DATA_05,  STR_POS_X, STR_LINE5_POS_Y,
    6*8,STR_LINE5_POS_Y,8*8,TOUCH_H,
    LANGCODE_00,7+1,EDITBOX_ID_BASIC_LANG },
  //ロムバージョン
  {STR_TYPE_SWITCH, RESORT_DATA_06,  15*8, STR_LINE5_POS_Y,
    23*8,STR_LINE5_POS_Y,8*8,TOUCH_H,
    CASETTE_00,15+1,EDITBOX_ID_BASIC_VER },
  //見た目
  {STR_TYPE_NUM, RESORT_DATA_07,  STR_POS_X, STR_LINE6_POS_Y,
    4*8,STR_LINE6_POS_Y,12*8,TOUCH_H,
    343, 0,EDITBOX_ID_BASIC_VIEW },
  //性別
  {STR_TYPE_SWITCH, RESORT_DATA_08,  18*8, STR_LINE6_POS_Y,
    23*8,STR_LINE6_POS_Y,3*8,TOUCH_H,
    SEX_00,2,EDITBOX_ID_BASIC_SEX },
  //プレイ時間
  {STR_TYPE_CAPTION, RESORT_DATA_09,  STR_POS_X, STR_LINE7_POS_Y,
    0,0,0,0,
    0,0,0 },
  //時
  {STR_TYPE_NUM, RESORT_DATA_12,  8*8+STR_POS_X, STR_LINE7_POS_Y,
    8*8+2*8,STR_LINE7_POS_Y,3*8,TOUCH_H,
    24,0,EDITBOX_ID_BASIC_PLAY_HOUR },
  //分
  {STR_TYPE_NUM, RESORT_DATA_13,  8*8+6*8, STR_LINE7_POS_Y,
    8*8+8*8,STR_LINE7_POS_Y,3*8,TOUCH_H,
    59,0,EDITBOX_ID_BASIC_PLAY_MIN },
};

//住民準基本データ
static const STR_PARAM StrParamsResidentBasicSub[] = 
{
  //住民基礎情報
  {STR_TYPE_CAPTION, RESORT_DATA_23,  STR_POS_X, STR_LINE0_POS_Y,
    0,0,0,0,
    0,0,0 },
  //特別配信
  {STR_TYPE_SWITCH, RESORT_DATA_26,  16*8+STR_POS_X, STR_LINE1_POS_Y,
    16*8+5*8,STR_LINE1_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_SUB_SPECIAL },
  //なりたい施設
  {STR_TYPE_NUM, RESORT_DATA_25,  STR_POS_X, STR_LINE1_POS_Y,
    6*8,STR_LINE1_POS_Y,4*8,TOUCH_H,
    RESORT_SHOP_ID_MAX,0,EDITBOX_ID_SUB_WANTJOB },
  //街レベル
  {STR_TYPE_NUM, RESORT_DATA_24,  STR_POS_X, STR_LINE2_POS_Y,
    4*8,STR_LINE2_POS_Y,5*8,TOUCH_H,
    RESORT_SHOP_ID_MAX,0,EDITBOX_ID_SUB_CITYLV },
  //住民生成データ
  {STR_TYPE_CAPTION, RESORT_DATA_31,  STR_POS_X, STR_LINE5_POS_Y,
    0,0,0,0,
    0,0,0 },
  //プレゼントID
  {STR_TYPE_NUM, RESORT_DATA_32,  STR_POS_X, STR_LINE6_POS_Y,
    8*8,STR_LINE6_POS_Y,6*8,TOUCH_H,
    512,0,EDITBOX_ID_RESI_PRESENT_ID },
  //出会った
  {STR_TYPE_CAPTION, RESORT_DATA_34,  STR_POS_X, STR_LINE7_POS_Y,
    0,0,0,0,
    0,0,0 },
  //年
  {STR_TYPE_NUM, RESORT_DATA_10,  7*8+STR_POS_X, STR_LINE7_POS_Y,
    7*8+2*8,STR_LINE7_POS_Y,3*8,TOUCH_H,
    99,0,EDITBOX_ID_RESI_MEET_YEAR },
  //月
  {STR_TYPE_NUM, RESORT_DATA_11,  12*8+STR_POS_X, STR_LINE7_POS_Y,
    12*8+2*8,STR_LINE7_POS_Y,3*8,TOUCH_H,
    12,0,EDITBOX_ID_RESI_MEET_MONTH },
  //日
  {STR_TYPE_NUM, RESORT_DATA_11_01,  17*8+STR_POS_X, STR_LINE7_POS_Y,
    17*8+2*8,STR_LINE7_POS_Y,3*8,TOUCH_H,
    31,0,EDITBOX_ID_RESI_MEET_DAY },
  //時
  {STR_TYPE_NUM, RESORT_DATA_12,  22*8+STR_POS_X, STR_LINE7_POS_Y,
    22*8+2*8,STR_LINE7_POS_Y,3*8,TOUCH_H,
    24,0,EDITBOX_ID_RESI_MEET_HOUR },
  //分
  {STR_TYPE_NUM, RESORT_DATA_13,  27*8+STR_POS_X, STR_LINE7_POS_Y,
    27*8+2*8,STR_LINE7_POS_Y,3*8,TOUCH_H,
    59,0,EDITBOX_ID_RESI_MEET_MIN },
  //通信ID
  {STR_TYPE_NUM, RESORT_DATA_35,  STR_POS_X, STR_LINE8_POS_Y,
    6*8,STR_LINE8_POS_Y,4*8,TOUCH_H,
    255,0,EDITBOX_ID_RESI_COMM_ID },
  //マージ
  {STR_TYPE_SWITCH, RESORT_DATA_36,  10*8+STR_POS_X, STR_LINE8_POS_Y,
    10*8+4*8,STR_LINE8_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_RESI_MERGE },
  //固定
  {STR_TYPE_SWITCH, RESORT_DATA_37,  16*8+STR_POS_X, STR_LINE8_POS_Y,
    16*8+4*8,STR_LINE8_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_RESI_KEEP },
  //施設ID
  {STR_TYPE_NUM, RESORT_DATA_43,  STR_POS_X, STR_LINE9_POS_Y,
    4*8,STR_LINE9_POS_Y,4*8,TOUCH_H,
    RESORT_SHOP_ID_MAX,0,EDITBOX_ID_RESI_INSTITUTION_ID },
  //レベル
  {STR_TYPE_NUM, RESORT_DATA_38,  8*8+STR_POS_X, STR_LINE9_POS_Y,
    8*8+4*8,STR_LINE9_POS_Y,4*8,TOUCH_H,
    RESORT_SHOP_LVMAX,0,EDITBOX_ID_RESI_LV },
  //経験値
  {STR_TYPE_NUM, RESORT_DATA_39,  16*8+STR_POS_X, STR_LINE9_POS_Y,
    16*8+4*8,STR_LINE9_POS_Y,4*8,TOUCH_H,
    100,0,EDITBOX_ID_RESI_EXP },
  //イベントワーク１
  {STR_TYPE_NUM, RESORT_DATA_40,  STR_POS_X, STR_LINE10_POS_Y,
    8*8,STR_LINE10_POS_Y,6*8,TOUCH_H,
    0xFF,0,EDITBOX_ID_RESI_EV_WK_00 },
  //イベントワーク２
  {STR_TYPE_NUM, RESORT_DATA_41,  14*8+STR_POS_X, STR_LINE10_POS_Y,
    14*8+8*8,STR_LINE10_POS_Y,6*8,TOUCH_H,
    0xFF,0,EDITBOX_ID_RESI_EV_WK_01 },
  //イベントbit
  {STR_TYPE_BIT, RESORT_DATA_42,  STR_POS_X, STR_LINE11_POS_Y,
    7*8,STR_LINE11_POS_Y,16*8,TOUCH_H,
    16,0,EDITBOX_ID_RESI_EV_BIT },
  //結合bit
  {STR_TYPE_BIT, RESORT_DATA_44,  STR_POS_X, STR_LINE12_POS_Y,
    7*8,STR_LINE12_POS_Y,16*8,TOUCH_H,
    16,0,EDITBOX_ID_RESI_EXTEND_BIT },
  //人物ID
  {STR_TYPE_NUM, RESORT_DATA_45,  STR_POS_X, STR_LINE13_POS_Y,
    4*8,STR_LINE13_POS_Y,6*8,TOUCH_H,
    32,0,EDITBOX_ID_RESI_PEOPLE_ID },
  //場所ID
  {STR_TYPE_SWITCH, RESORT_DATA_46,  10*8+STR_POS_X, STR_LINE13_POS_Y,
    10*8+4*8,STR_LINE13_POS_Y,8*8,TOUCH_H,
    PLACE_00,17,EDITBOX_ID_RESI_PLACE_ID },
  //タイプ
  {STR_TYPE_NUM, RESORT_DATA_82,  24*8+STR_POS_X, STR_LINE13_POS_Y,
    28*8,STR_LINE13_POS_Y,4*8,TOUCH_H,
    32,0,EDITBOX_ID_RESI_TYPE },
  //個性
  {STR_TYPE_NUM, RESORT_DATA_47,  STR_POS_X, STR_LINE14_POS_Y,
    4*8,STR_LINE14_POS_Y,8*8,TOUCH_H,
    32,0,EDITBOX_ID_RESI_KOSEI },
  //更新
  {STR_TYPE_NUM, RESORT_DATA_83,  13*8+STR_POS_X, STR_LINE14_POS_Y,
    17*8,STR_LINE14_POS_Y,4*8,TOUCH_H,
    10,0,EDITBOX_ID_RESI_UPDATE },
};

//住民拡張123データ
static const STR_PARAM StrParamsResidentExtend123[] = 
{
  //拡張１データ
  {STR_TYPE_CAPTION, RESORT_DATA_48,  STR_POS_X, STR_LINE0_POS_Y,
    0,0,0,0,
    0,0,0 },
  //メダルビット
  {STR_TYPE_CAPTION, RESORT_DATA_49,  STR_POS_X, STR_LINE1_POS_Y,
    0,0,0,0,
    0,0,0},
  //イチオシ
  {STR_TYPE_CAPTION, RESORT_DATA_50,  STR_POS_X, STR_LINE5_POS_Y,
    0,0,0,0,
    0,0,0},
  //メダルID
  {STR_TYPE_NUM, RESORT_DATA_51,  10*8+STR_POS_X, STR_LINE5_POS_Y,
    10*8+2*8,STR_LINE5_POS_Y,3*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT1_MEDAL_ID },
  //メダル年
  {STR_TYPE_NUM, RESORT_DATA_10,  15*8+STR_POS_X, STR_LINE5_POS_Y,
    15*8+2*8,STR_LINE5_POS_Y,3*8,TOUCH_H,
    99,0,EDITBOX_ID_EXT1_MEDAL_YEAR },
  //メダル月
  {STR_TYPE_NUM, RESORT_DATA_11,  20*8+STR_POS_X, STR_LINE5_POS_Y,
    20*8+2*8,STR_LINE5_POS_Y,3*8,TOUCH_H,
    12,0,EDITBOX_ID_EXT1_MEDAL_MONTH },
  //メダル日
  {STR_TYPE_NUM, RESORT_DATA_11_01,  25*8+STR_POS_X, STR_LINE5_POS_Y,
    25*8+2*8,STR_LINE5_POS_Y,3*8,TOUCH_H,
    31,0,EDITBOX_ID_EXT1_MEDAL_DAY },
  //メダル獲得数
  {STR_TYPE_NUM, RESORT_DATA_52,  STR_POS_X, STR_LINE6_POS_Y,
    8*8,STR_LINE6_POS_Y,4*8,TOUCH_H,
    512,0,EDITBOX_ID_EXT1_MEDAL_NUM },

  //拡張2データ
  {STR_TYPE_CAPTION, RESORT_DATA_53,  STR_POS_X, STR_LINE7_POS_Y,
    0,0,0,0,
    0,0,0 },
  //ランキング１
  {STR_TYPE_NUM, RESORT_DATA_54,STR_POS_X, STR_LINE8_POS_Y,
    7*8,STR_LINE8_POS_Y,6*8,TOUCH_H,
    0xFFFF,0,EDITBOX_ID_EXT2_RANK_00 },
  //ランキング２
  {STR_TYPE_NUM, RESORT_DATA_55,13*8+STR_POS_X, STR_LINE8_POS_Y,
    13*8+7*8,STR_LINE8_POS_Y,6*8,TOUCH_H,
    0xFFFF,0,EDITBOX_ID_EXT2_RANK_01 },
  //ランキング３
  {STR_TYPE_NUM, RESORT_DATA_54,STR_POS_X, STR_LINE9_POS_Y,
    7*8,STR_LINE9_POS_Y,6*8,TOUCH_H,
    0xFFFF,0,EDITBOX_ID_EXT2_RANK_02 },
  //ランキング４
  {STR_TYPE_NUM, RESORT_DATA_55,13*8+STR_POS_X, STR_LINE9_POS_Y,
    13*8+7*8,STR_LINE9_POS_Y,6*8,TOUCH_H,
    0xFFFF,0,EDITBOX_ID_EXT2_RANK_03 },

  //拡張3データ
  {STR_TYPE_CAPTION, RESORT_DATA_58,  STR_POS_X, STR_LINE10_POS_Y,
    0,0,0,0,
    0,0,0 },
  //ランキング５
  {STR_TYPE_NUM, RESORT_DATA_59,STR_POS_X, STR_LINE11_POS_Y,
    7*8,STR_LINE11_POS_Y,6*8,TOUCH_H,
    0xFFFF,0,EDITBOX_ID_EXT3_RANK_04 },
  //ランキング６
  {STR_TYPE_NUM, RESORT_DATA_60,13*8+STR_POS_X, STR_LINE11_POS_Y,
    13*8+7*8,STR_LINE11_POS_Y,6*8,TOUCH_H,
    0xFFFF,0,EDITBOX_ID_EXT3_RANK_05 },
  //ランキング７
  {STR_TYPE_NUM, RESORT_DATA_61,STR_POS_X, STR_LINE12_POS_Y,
    7*8,STR_LINE12_POS_Y,6*8,TOUCH_H,
    0xFFFF,0,EDITBOX_ID_EXT3_RANK_06 },
  //ランキング８
  {STR_TYPE_NUM, RESORT_DATA_62,13*8+STR_POS_X, STR_LINE12_POS_Y,
    13*8+7*8,STR_LINE12_POS_Y,6*8,TOUCH_H,
    0xFFFF,0,EDITBOX_ID_EXT3_RANK_07 },
};

//住民拡張4データ
static const STR_PARAM StrParamsResidentExtend4[] = 
{
  //拡張3データ
  {STR_TYPE_CAPTION, RESORT_DATA_63,  STR_POS_X, STR_LINE0_POS_Y,
    0,0,0,0,
    0,0,0 },
  //噂
  {STR_TYPE_CAPTION, RESORT_DATA_64,  STR_POS_X, STR_LINE1_POS_Y,
    0,0,0,0,
    0,0,0 },
  {STR_TYPE_NUM, RESORT_DATA_115,  STR_POS_X, STR_LINE2_POS_Y,
    40, STR_LINE2_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_00 },
  {STR_TYPE_NUM, RESORT_DATA_116,  40+7*8+STR_POS_X, STR_LINE2_POS_Y,
    80+7*8+8, STR_LINE2_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_01 },
  {STR_TYPE_NUM, RESORT_DATA_117,  STR_POS_X, STR_LINE3_POS_Y,
    40, STR_LINE3_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_02 },
  {STR_TYPE_NUM, RESORT_DATA_118,  40+7*8+STR_POS_X, STR_LINE3_POS_Y,
    80+7*8+8, STR_LINE3_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_03 },
  {STR_TYPE_NUM, RESORT_DATA_119,  STR_POS_X, STR_LINE4_POS_Y,
    40, STR_LINE4_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_04 },
  {STR_TYPE_NUM, RESORT_DATA_120,  40+7*8+STR_POS_X, STR_LINE4_POS_Y,
    80+7*8+8, STR_LINE4_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_05 },
  {STR_TYPE_NUM, RESORT_DATA_121,  STR_POS_X, STR_LINE5_POS_Y,
    40, STR_LINE5_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_06 },
  {STR_TYPE_NUM, RESORT_DATA_122,  40+7*8+STR_POS_X, STR_LINE5_POS_Y,
    80+7*8+8, STR_LINE5_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_07 },
  {STR_TYPE_NUM, RESORT_DATA_123,  STR_POS_X, STR_LINE6_POS_Y,
    40, STR_LINE6_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_08 },
  {STR_TYPE_NUM, RESORT_DATA_124,  40+7*8+STR_POS_X, STR_LINE6_POS_Y,
    80+7*8+8, STR_LINE6_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_09 },
  {STR_TYPE_NUM, RESORT_DATA_125,  STR_POS_X, STR_LINE7_POS_Y,
    40, STR_LINE7_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_10 },
  {STR_TYPE_NUM, RESORT_DATA_126,  40+7*8+STR_POS_X, STR_LINE7_POS_Y,
    80+7*8+8, STR_LINE7_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_11 },
  {STR_TYPE_NUM, RESORT_DATA_127,  STR_POS_X, STR_LINE8_POS_Y,
    40, STR_LINE8_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_12 },
  {STR_TYPE_NUM, RESORT_DATA_128,  40+7*8+STR_POS_X, STR_LINE8_POS_Y,
    80+7*8+8, STR_LINE8_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_13 },
  {STR_TYPE_NUM, RESORT_DATA_129,  STR_POS_X, STR_LINE9_POS_Y,
    40, STR_LINE9_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_14 },
  {STR_TYPE_NUM, RESORT_DATA_130,  40+7*8+STR_POS_X, STR_LINE9_POS_Y,
    80+7*8+8, STR_LINE9_POS_Y,6*8,TOUCH_H,
    255,0,EDITBOX_ID_EXT4_GOSSIP_15 },
};

//住民拡張567データ
static const STR_PARAM StrParamsResidentExtend567[] = 
{
  //拡張5データ
  {STR_TYPE_CAPTION, RESORT_DATA_65,  STR_POS_X, STR_LINE0_POS_Y,
    0,0,0,0,
    0,0,0 },
  //モンスターNo
  {STR_TYPE_STR, RESORT_DATA_68,  STR_POS_X, STR_LINE1_POS_Y,
    5*8,STR_LINE1_POS_Y,7*8,TOUCH_H,
    NARC_message_monsname_dat,0,EDITBOX_ID_EXT5_MONSNO },
  //性別
  {STR_TYPE_SWITCH, RESORT_DATA_71,  12*8+STR_POS_X, STR_LINE1_POS_Y,
    12*8+3*8,STR_LINE1_POS_Y,2*8,TOUCH_H,
    SEX_00,3,EDITBOX_ID_EXT5_SEX },
  //フォルム
  {STR_TYPE_NUM, RESORT_DATA_70, 17*8+STR_POS_X, STR_LINE1_POS_Y,
    17*8+4*8,STR_LINE1_POS_Y,3*8,TOUCH_H,
    32,0,EDITBOX_ID_EXT5_FORM },
  //レア
  {STR_TYPE_SWITCH, RESORT_DATA_72,  24*8+STR_POS_X, STR_LINE1_POS_Y,
    24*8+3*8,STR_LINE1_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_EXT5_RARE },
  //とくせい
  {STR_TYPE_STR, RESORT_DATA_69,  STR_POS_X, STR_LINE2_POS_Y,
    5*8,STR_LINE2_POS_Y,7*8,TOUCH_H,
    NARC_message_tokusei_dat,0,EDITBOX_ID_EXT5_TOKUSEI },
  //アイテム
  {STR_TYPE_STR, RESORT_DATA_74,  12*8+STR_POS_X, STR_LINE2_POS_Y,
    12*8+5*8,STR_LINE2_POS_Y,7*8,TOUCH_H,
    NARC_message_itemname_dat,0,EDITBOX_ID_EXT5_ITEM },
  //わざ
  {STR_TYPE_CAPTION, RESORT_DATA_73,  STR_POS_X, STR_LINE3_POS_Y,
    0,0,0,0,
    0,0,0 },
  //わざ１
  {STR_TYPE_STR, CAPTION_NONE,  3*8+STR_POS_X, STR_LINE3_POS_Y,
    3*8,STR_LINE3_POS_Y,7*8,TOUCH_H,
    NARC_message_wazaname_dat,0,EDITBOX_ID_EXT5_WAZA_00 },
  //わざ２
  {STR_TYPE_STR, CAPTION_NONE,  10*8+3*8+STR_POS_X, STR_LINE3_POS_Y,
    10*8+8,STR_LINE3_POS_Y,7*8,TOUCH_H,
    NARC_message_wazaname_dat,0,EDITBOX_ID_EXT5_WAZA_01 },
  //わざ３
  {STR_TYPE_STR, CAPTION_NONE,  3*8+STR_POS_X, STR_LINE4_POS_Y,
    3*8,STR_LINE4_POS_Y,7*8,TOUCH_H,
    NARC_message_wazaname_dat,0,EDITBOX_ID_EXT5_WAZA_02 },
  //わざ４
  {STR_TYPE_STR, CAPTION_NONE,  10*8+3*8+STR_POS_X, STR_LINE4_POS_Y,
    10*8+8,STR_LINE4_POS_Y,7*8,TOUCH_H,
    NARC_message_wazaname_dat,0,EDITBOX_ID_EXT5_WAZA_03 },

  //拡張6データ
  {STR_TYPE_CAPTION, RESORT_DATA_66,  STR_POS_X, STR_LINE5_POS_Y,
    0,0,0,0,
    0,0,0 },
  //モンスターNo
  {STR_TYPE_STR, RESORT_DATA_68,  STR_POS_X, STR_LINE6_POS_Y,
    5*8,STR_LINE6_POS_Y,7*8,TOUCH_H,
    NARC_message_monsname_dat,0,EDITBOX_ID_EXT6_MONSNO },
  //性別
  {STR_TYPE_SWITCH, RESORT_DATA_71,  12*8+STR_POS_X, STR_LINE6_POS_Y,
    12*8+3*8,STR_LINE6_POS_Y,2*8,TOUCH_H,
    SEX_00,3,EDITBOX_ID_EXT6_SEX },
  //フォルム
  {STR_TYPE_NUM, RESORT_DATA_70, 17*8+STR_POS_X, STR_LINE6_POS_Y,
    17*8+4*8,STR_LINE6_POS_Y,3*8,TOUCH_H,
    32,0,EDITBOX_ID_EXT6_FORM },
  //レア
  {STR_TYPE_SWITCH, RESORT_DATA_72,  24*8+STR_POS_X, STR_LINE6_POS_Y,
    24*8+3*8,STR_LINE6_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_EXT6_RARE },
  //とくせい
  {STR_TYPE_STR, RESORT_DATA_69,  STR_POS_X, STR_LINE7_POS_Y,
    5*8,STR_LINE7_POS_Y,7*8,TOUCH_H,
    NARC_message_tokusei_dat,0,EDITBOX_ID_EXT6_TOKUSEI },
  //アイテム
  {STR_TYPE_STR, RESORT_DATA_74,  12*8+STR_POS_X, STR_LINE7_POS_Y,
    12*8+5*8,STR_LINE7_POS_Y,7*8,TOUCH_H,
    NARC_message_itemname_dat,0,EDITBOX_ID_EXT6_ITEM },
  //わざ
  {STR_TYPE_CAPTION, RESORT_DATA_73,  STR_POS_X, STR_LINE8_POS_Y,
    0,0,0,0,
    0,0,0 },
  //わざ１
  {STR_TYPE_STR, CAPTION_NONE,  3*8+STR_POS_X, STR_LINE8_POS_Y,
    3*8,STR_LINE8_POS_Y,7*8,TOUCH_H,
    NARC_message_wazaname_dat,0,EDITBOX_ID_EXT6_WAZA_00 },
  //わざ２
  {STR_TYPE_STR, CAPTION_NONE,  10*8+3*8+STR_POS_X, STR_LINE8_POS_Y,
    10*8+8,STR_LINE8_POS_Y,7*8,TOUCH_H,
    NARC_message_wazaname_dat,0,EDITBOX_ID_EXT6_WAZA_01 },
  //わざ３
  {STR_TYPE_STR, CAPTION_NONE,  3*8+STR_POS_X, STR_LINE9_POS_Y,
    3*8,STR_LINE9_POS_Y,7*8,TOUCH_H,
    NARC_message_wazaname_dat,0,EDITBOX_ID_EXT6_WAZA_02 },
  //わざ４
  {STR_TYPE_STR, CAPTION_NONE,  10*8+3*8+STR_POS_X, STR_LINE9_POS_Y,
    10*8+8,STR_LINE9_POS_Y,7*8,TOUCH_H,
    NARC_message_wazaname_dat,0,EDITBOX_ID_EXT6_WAZA_03 },


  //拡張7データ
  {STR_TYPE_CAPTION, RESORT_DATA_67,  STR_POS_X, STR_LINE10_POS_Y,
    0,0,0,0,
    0,0,0 },
  //モンスターNo
  {STR_TYPE_STR, RESORT_DATA_68,  STR_POS_X, STR_LINE11_POS_Y,
    5*8,STR_LINE11_POS_Y,7*8,TOUCH_H,
    NARC_message_monsname_dat,0,EDITBOX_ID_EXT7_MONSNO },
  //性別
  {STR_TYPE_SWITCH, RESORT_DATA_71,  12*8+STR_POS_X, STR_LINE11_POS_Y,
    12*8+3*8,STR_LINE11_POS_Y,2*8,TOUCH_H,
    SEX_00,3,EDITBOX_ID_EXT7_SEX },
  //フォルム
  {STR_TYPE_NUM, RESORT_DATA_70, 17*8+STR_POS_X, STR_LINE11_POS_Y,
    17*8+4*8,STR_LINE11_POS_Y,3*8,TOUCH_H,
    32,0,EDITBOX_ID_EXT7_FORM },
  //レア
  {STR_TYPE_SWITCH, RESORT_DATA_72,  24*8+STR_POS_X, STR_LINE11_POS_Y,
    24*8+3*8,STR_LINE11_POS_Y,2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_EXT7_RARE },
  //とくせい
  {STR_TYPE_STR, RESORT_DATA_69,  STR_POS_X, STR_LINE12_POS_Y,
    5*8,STR_LINE12_POS_Y,7*8,TOUCH_H,
    NARC_message_tokusei_dat,0,EDITBOX_ID_EXT7_TOKUSEI },
  //アイテム
  {STR_TYPE_STR, RESORT_DATA_74,  12*8+STR_POS_X, STR_LINE12_POS_Y,
    12*8+5*8,STR_LINE12_POS_Y,7*8,TOUCH_H,
    NARC_message_itemname_dat,0,EDITBOX_ID_EXT7_ITEM },
  //わざ
  {STR_TYPE_CAPTION, RESORT_DATA_73,  STR_POS_X, STR_LINE13_POS_Y,
    0,0,0,0,
    0,0,0 },
  //わざ１
  {STR_TYPE_STR, CAPTION_NONE,  3*8+STR_POS_X, STR_LINE13_POS_Y,
    3*8,STR_LINE13_POS_Y,7*8,TOUCH_H,
    NARC_message_wazaname_dat,0,EDITBOX_ID_EXT7_WAZA_00 },
  //わざ２
  {STR_TYPE_STR, CAPTION_NONE,  10*8+3*8+STR_POS_X, STR_LINE13_POS_Y,
    10*8+8,STR_LINE13_POS_Y,7*8,TOUCH_H,
    NARC_message_wazaname_dat,0,EDITBOX_ID_EXT7_WAZA_01 },
  //わざ３
  {STR_TYPE_STR, CAPTION_NONE,  3*8+STR_POS_X, STR_LINE14_POS_Y,
    3*8,STR_LINE14_POS_Y,7*8,TOUCH_H,
    NARC_message_wazaname_dat,0,EDITBOX_ID_EXT7_WAZA_02 },
  //わざ４
  {STR_TYPE_STR, CAPTION_NONE,  10*8+3*8+STR_POS_X, STR_LINE14_POS_Y,
    10*8+8,STR_LINE14_POS_Y,7*8,TOUCH_H,
    NARC_message_wazaname_dat,0,EDITBOX_ID_EXT7_WAZA_03 },
};

//住民拡張89データ
static const STR_PARAM StrParamsResidentExtend89[] = 
{
  //拡張8データ
  {STR_TYPE_CAPTION, RESORT_DATA_75,  STR_POS_X, STR_LINE0_POS_Y,
    0,0,0,0,
    0,0,0 },
  //履歴１
  {STR_TYPE_NUM, RESORT_DATA_77,  STR_POS_X, STR_LINE1_POS_Y,
    4*8,STR_LINE1_POS_Y,6*8,TOUCH_H,
    0xFFFF,0,EDITBOX_ID_EXT8_RECORD_00 },
  //履歴年１
  {STR_TYPE_NUM, RESORT_DATA_10,  10*8+STR_POS_X, STR_LINE1_POS_Y,
    10*8+3*8,STR_LINE1_POS_Y,2*8,TOUCH_H,
    99,0,EDITBOX_ID_EXT8_RECORD_YEAR_00 },
  //履歴月１
  {STR_TYPE_NUM, RESORT_DATA_11,  15*8+STR_POS_X, STR_LINE1_POS_Y,
    15*8+3*8,STR_LINE1_POS_Y,2*8,TOUCH_H,
    12,0,EDITBOX_ID_EXT8_RECORD_MONTH_00 },
  //履歴日１
  {STR_TYPE_NUM, RESORT_DATA_11_01,  20*8+STR_POS_X, STR_LINE1_POS_Y,
    20*8+3*8,STR_LINE1_POS_Y,2*8,TOUCH_H,
    31,0,EDITBOX_ID_EXT8_RECORD_DAY_00 },
  //履歴２
  {STR_TYPE_NUM, RESORT_DATA_77,  STR_POS_X, STR_LINE2_POS_Y,
    4*8,STR_LINE2_POS_Y,6*8,TOUCH_H,
    0xFFFF,0,EDITBOX_ID_EXT8_RECORD_01 },
  //履歴年２
  {STR_TYPE_NUM, RESORT_DATA_10,  10*8+STR_POS_X, STR_LINE2_POS_Y,
    10*8+3*8,STR_LINE2_POS_Y,2*8,TOUCH_H,
    99,0,EDITBOX_ID_EXT8_RECORD_YEAR_01 },
  //履歴月２
  {STR_TYPE_NUM, RESORT_DATA_11,  15*8+STR_POS_X, STR_LINE2_POS_Y,
    15*8+3*8,STR_LINE2_POS_Y,2*8,TOUCH_H,
    12,0,EDITBOX_ID_EXT8_RECORD_MONTH_01 },
  //履歴日２
  {STR_TYPE_NUM, RESORT_DATA_11_01,  20*8+STR_POS_X, STR_LINE2_POS_Y,
    20*8+3*8,STR_LINE2_POS_Y,2*8,TOUCH_H,
    31,0,EDITBOX_ID_EXT8_RECORD_DAY_01 },
  //履歴３
  {STR_TYPE_NUM, RESORT_DATA_77,  STR_POS_X, STR_LINE3_POS_Y,
    4*8,STR_LINE3_POS_Y,6*8,TOUCH_H,
    0xFFFF,0,EDITBOX_ID_EXT8_RECORD_02 },
  //履歴年３
  {STR_TYPE_NUM, RESORT_DATA_10,  10*8+STR_POS_X, STR_LINE3_POS_Y,
    10*8+3*8,STR_LINE3_POS_Y,2*8,TOUCH_H,
    99,0,EDITBOX_ID_EXT8_RECORD_YEAR_02 },
  //履歴月３
  {STR_TYPE_NUM, RESORT_DATA_11,  15*8+STR_POS_X, STR_LINE3_POS_Y,
    15*8+3*8,STR_LINE3_POS_Y,2*8,TOUCH_H,
    12,0,EDITBOX_ID_EXT8_RECORD_MONTH_02 },
  //履歴日３
  {STR_TYPE_NUM, RESORT_DATA_11_01,  20*8+STR_POS_X, STR_LINE3_POS_Y,
    20*8+3*8,STR_LINE3_POS_Y,2*8,TOUCH_H,
    31,0,EDITBOX_ID_EXT8_RECORD_DAY_02 },
  //履歴４
  {STR_TYPE_NUM, RESORT_DATA_77,  STR_POS_X, STR_LINE4_POS_Y,
    4*8,STR_LINE4_POS_Y,6*8,TOUCH_H,
    0xFFFF,0,EDITBOX_ID_EXT8_RECORD_03 },
  //履歴年４
  {STR_TYPE_NUM, RESORT_DATA_10,  10*8+STR_POS_X, STR_LINE4_POS_Y,
    10*8+3*8,STR_LINE4_POS_Y,2*8,TOUCH_H,
    99,0,EDITBOX_ID_EXT8_RECORD_YEAR_03 },
  //履歴月４
  {STR_TYPE_NUM, RESORT_DATA_11,  15*8+STR_POS_X, STR_LINE4_POS_Y,
    15*8+3*8,STR_LINE4_POS_Y,2*8,TOUCH_H,
    12,0,EDITBOX_ID_EXT8_RECORD_MONTH_03 },
  //履歴日４
  {STR_TYPE_NUM, RESORT_DATA_11_01,  20*8+STR_POS_X, STR_LINE4_POS_Y,
    20*8+3*8,STR_LINE4_POS_Y,2*8,TOUCH_H,
    31,0,EDITBOX_ID_EXT8_RECORD_DAY_03 },

  //拡張9データ
  {STR_TYPE_CAPTION, RESORT_DATA_76,  STR_POS_X, STR_LINE6_POS_Y,
    0,0,0,0,
    0,0,0 },
  //なまえ
  {STR_TYPE_EDITSTR, RESORT_DATA_81,  STR_POS_X, STR_LINE7_POS_Y,
    5*8,STR_LINE7_POS_Y,12*8,TOUCH_H,
    0,0,EDITBOX_ID_EXT6_PHRASE },
};

//お店配置ページ
#define HARF_LINE (128)
static const STR_PARAM StrParamsShopPos[] =
{
  //お店配置
  {STR_TYPE_CAPTION, PEOPLE_01,  STR_POS_X, STR_LINE0_POS_Y,
    0,0,0,0,
    0,0,0 },
  //お店８
  {STR_TYPE_CAPTION, RESORT_DATA_99,  STR_POS_X, STR_LINE2_POS_Y,
    0,0,0,0,
    0,0,0 },
  //お店ID
  {STR_TYPE_NUM, RESORT_DATA_43, STR_POS_X, STR_LINE3_POS_Y,
    32,STR_LINE3_POS_Y, 2*8,TOUCH_H,
    RESORT_SHOP_ID_MAX-1,0,EDITBOX_ID_SHOP_ID_07 },
  //お店種類
  {STR_TYPE_SWITCH, CAPTION_NONE,  STR_POS_X, STR_LINE3_POS_Y,
    70,STR_LINE3_POS_Y,6*8,TOUCH_H,
    SHOPTYPE_00, RESORT_RESIDENT_TYPE_MAX,EDITBOX_ID_SHOP_KIND_07 },
  //LV
  {STR_TYPE_NUM, RESORT_DATA_88,  STR_POS_X, STR_LINE4_POS_Y,
    16,STR_LINE4_POS_Y,2*8,TOUCH_H,
    RESORT_SHOP_LVMAX,0,EDITBOX_ID_SHOP_LV_07 },
  //EXP
  {STR_TYPE_NUM, RESORT_DATA_89,  32 + STR_POS_X, STR_LINE4_POS_Y,
    32+20,STR_LINE4_POS_Y,4*8,TOUCH_H,
    9999,0,EDITBOX_ID_SHOP_EXP_07 },
  //TYPE
  {STR_TYPE_SWITCH, RESORT_DATA_82,  88 + STR_POS_X, STR_LINE4_POS_Y,
    88+24,STR_LINE4_POS_Y,2*8,TOUCH_H,
    JAVER_00,4,EDITBOX_ID_SHOP_TYPE_07 },
  //お店７
  {STR_TYPE_CAPTION, RESORT_DATA_98,  HARF_LINE, STR_LINE2_POS_Y,
    0,0,0,0,
    0,0,0 },
  //お店ID
  {STR_TYPE_NUM, RESORT_DATA_43, HARF_LINE+STR_POS_X, STR_LINE3_POS_Y,
    HARF_LINE+32,STR_LINE3_POS_Y, 2*8,TOUCH_H,
    RESORT_SHOP_ID_MAX-1,0,EDITBOX_ID_SHOP_ID_06 },
  //お店種類
  {STR_TYPE_SWITCH, CAPTION_NONE,  HARF_LINE+STR_POS_X, STR_LINE3_POS_Y,
    HARF_LINE+70,STR_LINE3_POS_Y,6*8,TOUCH_H,
    SHOPTYPE_00, RESORT_RESIDENT_TYPE_MAX,EDITBOX_ID_SHOP_KIND_06 },
  //LV
  {STR_TYPE_NUM, RESORT_DATA_88,  HARF_LINE+STR_POS_X, STR_LINE4_POS_Y,
    HARF_LINE+16,STR_LINE4_POS_Y,2*8,TOUCH_H,
    RESORT_SHOP_LVMAX,0,EDITBOX_ID_SHOP_LV_06 },
  //EXP
  {STR_TYPE_NUM, RESORT_DATA_89,  HARF_LINE+32 + STR_POS_X, STR_LINE4_POS_Y,
    HARF_LINE+32+20,STR_LINE4_POS_Y,4*8,TOUCH_H,
    9999,0,EDITBOX_ID_SHOP_EXP_06 },
  //TYPE
  {STR_TYPE_SWITCH, RESORT_DATA_82,  HARF_LINE+88 + STR_POS_X, STR_LINE4_POS_Y,
    HARF_LINE+88+24,STR_LINE4_POS_Y,2*8,TOUCH_H,
    JAVER_00,4,EDITBOX_ID_SHOP_TYPE_06 },
  //お店６
  {STR_TYPE_CAPTION, RESORT_DATA_97,  STR_POS_X, STR_LINE5_POS_Y,
    0,0,0,0,
    0,0,0 },
  //お店ID
  {STR_TYPE_NUM, RESORT_DATA_43, STR_POS_X, STR_LINE6_POS_Y,
    32,STR_LINE6_POS_Y, 2*8,TOUCH_H,
    RESORT_SHOP_ID_MAX-1,0,EDITBOX_ID_SHOP_ID_05 },
  //お店種類
  {STR_TYPE_SWITCH, CAPTION_NONE,  STR_POS_X, STR_LINE6_POS_Y,
    70,STR_LINE6_POS_Y,6*8,TOUCH_H,
    SHOPTYPE_00, RESORT_RESIDENT_TYPE_MAX,EDITBOX_ID_SHOP_KIND_05 },
  //LV
  {STR_TYPE_NUM, RESORT_DATA_88,  STR_POS_X, STR_LINE7_POS_Y,
    16,STR_LINE7_POS_Y,2*8,TOUCH_H,
    RESORT_SHOP_LVMAX,0,EDITBOX_ID_SHOP_LV_05 },
  //EXP
  {STR_TYPE_NUM, RESORT_DATA_89,  32 + STR_POS_X, STR_LINE7_POS_Y,
    32+20,STR_LINE7_POS_Y,4*8,TOUCH_H,
    9999,0,EDITBOX_ID_SHOP_EXP_05 },
  //TYPE
  {STR_TYPE_SWITCH, RESORT_DATA_82,  88 + STR_POS_X, STR_LINE7_POS_Y,
    88+24,STR_LINE7_POS_Y,2*8,TOUCH_H,
    JAVER_00,4,EDITBOX_ID_SHOP_TYPE_05 },
  //お店５
  {STR_TYPE_CAPTION, RESORT_DATA_96,  HARF_LINE, STR_LINE5_POS_Y,
    0,0,0,0,
    0,0,0 },
  //お店ID
  {STR_TYPE_NUM, RESORT_DATA_43, HARF_LINE+STR_POS_X, STR_LINE6_POS_Y,
    HARF_LINE+32,STR_LINE6_POS_Y, 2*8,TOUCH_H,
    RESORT_SHOP_ID_MAX-1,0,EDITBOX_ID_SHOP_ID_04 },
  //お店種類
  {STR_TYPE_SWITCH, CAPTION_NONE,  HARF_LINE+STR_POS_X, STR_LINE6_POS_Y,
    HARF_LINE+70,STR_LINE6_POS_Y,6*8,TOUCH_H,
    SHOPTYPE_00, RESORT_RESIDENT_TYPE_MAX,EDITBOX_ID_SHOP_KIND_04 },
  //LV
  {STR_TYPE_NUM, RESORT_DATA_88,  HARF_LINE+STR_POS_X, STR_LINE7_POS_Y,
    HARF_LINE+16,STR_LINE7_POS_Y,2*8,TOUCH_H,
    RESORT_SHOP_LVMAX,0,EDITBOX_ID_SHOP_LV_04 },
  //EXP
  {STR_TYPE_NUM, RESORT_DATA_89,  HARF_LINE+32 + STR_POS_X, STR_LINE7_POS_Y,
    HARF_LINE+32+20,STR_LINE7_POS_Y,4*8,TOUCH_H,
    9999,0,EDITBOX_ID_SHOP_EXP_04 },
  //TYPE
  {STR_TYPE_SWITCH, RESORT_DATA_82,  HARF_LINE+88 + STR_POS_X, STR_LINE7_POS_Y,
    HARF_LINE+88+24,STR_LINE7_POS_Y,2*8,TOUCH_H,
    JAVER_00,4,EDITBOX_ID_SHOP_TYPE_04 },
  //お店４
  {STR_TYPE_CAPTION, RESORT_DATA_95,  STR_POS_X, STR_LINE8_POS_Y,
    0,0,0,0,
    0,0,0 },
  //お店ID
  {STR_TYPE_NUM, RESORT_DATA_43, STR_POS_X, STR_LINE9_POS_Y,
    32,STR_LINE9_POS_Y, 2*8,TOUCH_H,
    RESORT_SHOP_ID_MAX-1,0,EDITBOX_ID_SHOP_ID_03 },
  //お店種類
  {STR_TYPE_SWITCH, CAPTION_NONE,  STR_POS_X, STR_LINE9_POS_Y,
    70,STR_LINE9_POS_Y,6*8,TOUCH_H,
    SHOPTYPE_00, RESORT_RESIDENT_TYPE_MAX,EDITBOX_ID_SHOP_KIND_03 },
  //LV
  {STR_TYPE_NUM, RESORT_DATA_88,  STR_POS_X, STR_LINE10_POS_Y,
    16,STR_LINE10_POS_Y,2*8,TOUCH_H,
    RESORT_SHOP_LVMAX,0,EDITBOX_ID_SHOP_LV_03 },
  //EXP
  {STR_TYPE_NUM, RESORT_DATA_89,  32 + STR_POS_X, STR_LINE10_POS_Y,
    32+20,STR_LINE10_POS_Y,4*8,TOUCH_H,
    9999,0,EDITBOX_ID_SHOP_EXP_03 },
  //TYPE
  {STR_TYPE_SWITCH, RESORT_DATA_82,  88 + STR_POS_X, STR_LINE10_POS_Y,
    88+24,STR_LINE10_POS_Y,2*8,TOUCH_H,
    JAVER_00,4,EDITBOX_ID_SHOP_TYPE_03 },
  //お店３
  {STR_TYPE_CAPTION, RESORT_DATA_94,  HARF_LINE, STR_LINE8_POS_Y,
    0,0,0,0,
    0,0,0 },
  //お店ID
  {STR_TYPE_NUM, RESORT_DATA_43, HARF_LINE+STR_POS_X, STR_LINE9_POS_Y,
    HARF_LINE+32,STR_LINE9_POS_Y, 2*8,TOUCH_H,
    RESORT_SHOP_ID_MAX-1,0,EDITBOX_ID_SHOP_ID_02 },
  //お店種類
  {STR_TYPE_SWITCH, CAPTION_NONE,  HARF_LINE+STR_POS_X, STR_LINE9_POS_Y,
    HARF_LINE+70,STR_LINE9_POS_Y,6*8,TOUCH_H,
    SHOPTYPE_00, RESORT_RESIDENT_TYPE_MAX,EDITBOX_ID_SHOP_KIND_02 },
  //LV
  {STR_TYPE_NUM, RESORT_DATA_88,  HARF_LINE+STR_POS_X, STR_LINE10_POS_Y,
    HARF_LINE+16,STR_LINE10_POS_Y,2*8,TOUCH_H,
    RESORT_SHOP_LVMAX,0,EDITBOX_ID_SHOP_LV_02 },
  //EXP
  {STR_TYPE_NUM, RESORT_DATA_89,  HARF_LINE+32 + STR_POS_X, STR_LINE10_POS_Y,
    HARF_LINE+32+20,STR_LINE10_POS_Y,4*8,TOUCH_H,
    9999,0,EDITBOX_ID_SHOP_EXP_02 },
  //TYPE
  {STR_TYPE_SWITCH, RESORT_DATA_82,  HARF_LINE+88 + STR_POS_X, STR_LINE10_POS_Y,
    HARF_LINE+88+24,STR_LINE10_POS_Y,2*8,TOUCH_H,
    JAVER_00,4,EDITBOX_ID_SHOP_TYPE_02 },
  //お店２
  {STR_TYPE_CAPTION, RESORT_DATA_93,  STR_POS_X, STR_LINE11_POS_Y,
    0,0,0,0,
    0,0,0 },
  //お店ID
  {STR_TYPE_NUM, RESORT_DATA_43, STR_POS_X, STR_LINE12_POS_Y,
    32,STR_LINE12_POS_Y, 2*8,TOUCH_H,
    RESORT_SHOP_ID_MAX-1,0,EDITBOX_ID_SHOP_ID_01 },
  //お店種類
  {STR_TYPE_SWITCH, CAPTION_NONE,  STR_POS_X, STR_LINE12_POS_Y,
    70,STR_LINE12_POS_Y,6*8,TOUCH_H,
    SHOPTYPE_00, RESORT_RESIDENT_TYPE_MAX,EDITBOX_ID_SHOP_KIND_01 },
  //LV
  {STR_TYPE_NUM, RESORT_DATA_88,  STR_POS_X, STR_LINE13_POS_Y,
    16,STR_LINE13_POS_Y,2*8,TOUCH_H,
    RESORT_SHOP_LVMAX,0,EDITBOX_ID_SHOP_LV_01 },
  //EXP
  {STR_TYPE_NUM, RESORT_DATA_89,  32 + STR_POS_X, STR_LINE13_POS_Y,
    32+20,STR_LINE13_POS_Y,4*8,TOUCH_H,
    9999,0,EDITBOX_ID_SHOP_EXP_01 },
  //TYPE
  {STR_TYPE_SWITCH, RESORT_DATA_82,  88 + STR_POS_X, STR_LINE13_POS_Y,
    88+24,STR_LINE13_POS_Y,2*8,TOUCH_H,
    JAVER_00,4,EDITBOX_ID_SHOP_TYPE_01 },
  //お店１
  {STR_TYPE_CAPTION, RESORT_DATA_92,  HARF_LINE, STR_LINE11_POS_Y,
    0,0,0,0,
    0,0,0 },
  //お店ID
  {STR_TYPE_NUM, RESORT_DATA_43, HARF_LINE+STR_POS_X, STR_LINE12_POS_Y,
    HARF_LINE+32,STR_LINE12_POS_Y, 2*8,TOUCH_H,
    RESORT_SHOP_ID_MAX-1,0,EDITBOX_ID_SHOP_ID_00 },
  //お店種類
  {STR_TYPE_SWITCH, CAPTION_NONE,  HARF_LINE+STR_POS_X, STR_LINE12_POS_Y,
    HARF_LINE+70,STR_LINE12_POS_Y,6*8,TOUCH_H,
    SHOPTYPE_00, RESORT_RESIDENT_TYPE_MAX,EDITBOX_ID_SHOP_KIND_00 },
  //LV
  {STR_TYPE_NUM, RESORT_DATA_88,  HARF_LINE+STR_POS_X, STR_LINE13_POS_Y,
    HARF_LINE+16,STR_LINE13_POS_Y,2*8,TOUCH_H,
    RESORT_SHOP_LVMAX,0,EDITBOX_ID_SHOP_LV_00 },
  //EXP
  {STR_TYPE_NUM, RESORT_DATA_89,  HARF_LINE+32 + STR_POS_X, STR_LINE13_POS_Y,
    HARF_LINE+32+20,STR_LINE13_POS_Y,4*8,TOUCH_H,
    9999,0,EDITBOX_ID_SHOP_EXP_00 },
  //TYPE
  {STR_TYPE_SWITCH, RESORT_DATA_82,  HARF_LINE+88 + STR_POS_X, STR_LINE13_POS_Y,
    HARF_LINE+88+24,STR_LINE13_POS_Y,2*8,TOUCH_H,
    JAVER_00,4,EDITBOX_ID_SHOP_TYPE_00 },
};

//デバッグフラグ
static const STR_PARAM StrParamsDebugFlag[] =
{
  //デバッグフラグ
  {STR_TYPE_CAPTION, PEOPLE_05,  STR_POS_X, STR_LINE0_POS_Y,
    0,0,0,0,
    0,0,0 },
  //強制◎
  {STR_TYPE_SWITCH, RESORT_DATA_109, STR_POS_X, STR_LINE2_POS_Y,
    60,STR_LINE2_POS_Y, 2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_FLAG_00 },
  //EXP9999
  {STR_TYPE_SWITCH, RESORT_DATA_110, STR_POS_X, STR_LINE4_POS_Y,
    60,STR_LINE4_POS_Y, 2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_FLAG_01 },
  //強制セレブ
  {STR_TYPE_SWITCH, RESORT_DATA_111, STR_POS_X, STR_LINE6_POS_Y,
    60,STR_LINE6_POS_Y, 2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_FLAG_02 },
  //強制おみやげ
  {STR_TYPE_SWITCH, RESORT_DATA_112, STR_POS_X, STR_LINE8_POS_Y,
    60,STR_LINE8_POS_Y, 2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_FLAG_03 },
  //強制フィーバー
  {STR_TYPE_SWITCH, RESORT_DATA_113, STR_POS_X, STR_LINE10_POS_Y,
    60,STR_LINE10_POS_Y, 2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_FLAG_04 },
  //強制行きたいお店
  {STR_TYPE_NUM, RESORT_DATA_114, STR_POS_X, STR_LINE12_POS_Y,
    60,STR_LINE12_POS_Y, 3*8,TOUCH_H,
    RESORT_SPOT_ID_MAX,0,EDITBOX_ID_WORK_00 },
  //強制乱数固定
  {STR_TYPE_NUM, RESORT_DATA_133, STR_POS_X, STR_LINE14_POS_Y,
    60,STR_LINE14_POS_Y, 3*8,TOUCH_H,
    RESORT_SPOT_ID_MAX,0,EDITBOX_ID_WORK_01 },



  //強制初回コンボ必ず成功
  {STR_TYPE_SWITCH, RESORT_DATA_131, 100, STR_LINE2_POS_Y,
    100+60,STR_LINE2_POS_Y, 2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_FLAG_05 },

  //強制コンボ必ず最大連鎖
  {STR_TYPE_SWITCH, RESORT_DATA_132, 100, STR_LINE4_POS_Y,
    100+60,STR_LINE4_POS_Y, 2*8,TOUCH_H,
    YESNO_00,2,EDITBOX_ID_FLAG_06 },

};


static const STR_PARAM_DISPLAY sc_first_display_tbl[]  =
{
  //最初のページ
  {
    StrParamsFirst, NELEMS(StrParamsFirst)
  },
};
static const STR_PARAM_DISPLAY sc_city_display_tbl[]  =
{
  //街データのページ
  {
    StrParamsCity, NELEMS(StrParamsCity)
  },
};
static const STR_PARAM_DISPLAY sc_resident_display_tbl[]  =
{
  //住民基礎情報
  {
    StrParamsResidentBasic, NELEMS(StrParamsResidentBasic)
  },
  //住民準基礎情報
  {
    StrParamsResidentBasicSub, NELEMS(StrParamsResidentBasicSub)
  },
  //住民拡張データ１２３
  {
    StrParamsResidentExtend123, NELEMS(StrParamsResidentExtend123)
  },
  //住民拡張データ４
  {
    StrParamsResidentExtend4, NELEMS(StrParamsResidentExtend4)
  },
  //住民拡張データ５６７
/*  {
    StrParamsResidentExtend567, NELEMS(StrParamsResidentExtend567)
  },
*/  //住民拡張データ８９
  {
    StrParamsResidentExtend89, NELEMS(StrParamsResidentExtend89)
  },
};

static const STR_PARAM_DISPLAY sc_shoppos_display_tbl[]  =
{
  //お店配置
  {
    StrParamsShopPos, NELEMS(StrParamsShopPos)
  },
};
static const STR_PARAM_DISPLAY sc_debugflag_display_tbl[]  =
{
  //お店配置
  {
    StrParamsDebugFlag, NELEMS(StrParamsDebugFlag)
  },
};
static const STR_PARAM_PAGE sc_first_page =
{
  sc_first_display_tbl,
  NELEMS(sc_first_display_tbl),
  NULL,
  NULL,
  NULL,
};

static const STR_PARAM_PAGE sc_city_page =
{
  sc_city_display_tbl,
  NELEMS(sc_city_display_tbl),
  City_StoreData,
  City_ReStoreData,
  NULL,
};

static const STR_PARAM_PAGE sc_resident_page =
{
  sc_resident_display_tbl,
  NELEMS(sc_resident_display_tbl),
  Resident_StoreData,
  Resident_ReStoreData,
  NULL,
};

static const STR_PARAM_PAGE sc_tourist_page =
{
  sc_resident_display_tbl,
  NELEMS(sc_resident_display_tbl),
  Tourist_StoreData,
  Tourist_ReStoreData,
  NULL,
};

static const STR_PARAM_PAGE sc_owner_page =
{
  sc_resident_display_tbl,
  NELEMS(sc_resident_display_tbl),
  Owner_StoreData,
  Owner_ReStoreData,
  NULL,
};

static const STR_PARAM_PAGE sc_shoppos_page =
{
  sc_shoppos_display_tbl,
  NELEMS(sc_shoppos_display_tbl),
  ShopPos_StoreData,
  ShopPos_ReStoreData,
  ShopPos_PushCallback,
};
static const STR_PARAM_PAGE sc_debug_flag_page =
{
  sc_debugflag_display_tbl,
  NELEMS(sc_debugflag_display_tbl),
  DebugFlag_StoreData,
  DebugFlag_ReStoreData,
  NULL,
};

static GFL_PROC_RESULT DEBUG_INPUT_Resort_Init( GFL_PROC* proc, int* seq, void* pwk, void* mywk );
static GFL_PROC_RESULT DEBUG_INPUT_Resort_Main( GFL_PROC* proc, int* seq, void* pwk, void* mywk );
static GFL_PROC_RESULT DEBUG_INPUT_Resort_Quit( GFL_PROC* proc, int* seq, void* pwk, void* mywk );
static void SetupDisp( DEBUG_INPUT_WORK* wk );
static void CleanupDisp( DEBUG_INPUT_WORK* wk );
static BOOL MainCtrl( DEBUG_INPUT_WORK* wk );

static void PrintCaption( DEBUG_INPUT_WORK* wk, const STR_PARAM* p );
static int CheckBoxTouch( DEBUG_INPUT_WORK* wk );
static void UpdateBox( DEBUG_INPUT_WORK* wk, u32 inBoxID, u32 inValue );
static void UpdateStrBox( DEBUG_INPUT_WORK* wk, u32 inBoxID);
static PRINTSYS_LSB GetBoxSubBGColor( u8 inType );
static void GetBoxStr( DEBUG_INPUT_WORK* wk, u32 inBoxID, STRBUF* buf );
static u32 CalcDisit( u32 inValue );
static u64 Calc10To2( u32 in10, u32 keta );
static u32 Calc2To10( u64 in2, u32 keta );
static const STR_PARAM *GetBoxForEditBoxID( const DEBUG_INPUT_WORK* wk, u32 inBoxID );


static void NumInput_Setup( NUMINPUT_WORK* wk, STRBUF* buf, GFL_BMPWIN* win, GFL_FONT* font,
            PRINT_UTIL* util, PRINT_QUE* que, const STR_PARAM* strParam, u32 value, u32 keta, const DEBUG_INPUT_WORK* make_wk, NUMINPUT_TYPE type );
static BOOL NumInput_Main( NUMINPUT_WORK* wk );
static u32 NumInput_GetNum( NUMINPUT_WORK* wk );
static void DrawNumInput( NUMINPUT_WORK* wk );
static void SetAryNumInput( NUMINPUT_WORK* wk, u32 value );
static u64 CalcInputNum( NUMINPUT_WORK* wk );


static void COMPSKB_Setup( COMP_SKB_WORK* wk, GFL_SKB* skb, STRBUF* buf, u32 msgDataID, HEAPID heapID );
static void COMPSKB_Cleanup( COMP_SKB_WORK* wk );
static BOOL COMPSKB_Main( COMP_SKB_WORK* wk );
static int COMPSKB_GetWordIndex( const COMP_SKB_WORK* wk );
static BOOL compskb_strncmp( const STRBUF* str1, const STRBUF* str2, u32 len );
static u32 compskb_search( COMP_SKB_WORK* wk, const STRBUF* word, int org_idx, int* first_idx );
static BOOL comskb_is_match( COMP_SKB_WORK* wk, const STRBUF* word, int* match_idx );
static BOOL is_hiragana( const STRBUF* buf );

//ページ
static const STR_PARAM_DISPLAY *Page_GetStrParamDisplay( STR_PARAM_PAGE_STACK *p_wk );
static void Page_NextPage( STR_PARAM_PAGE_STACK *p_wk );
static void Page_PrevPage( STR_PARAM_PAGE_STACK *p_wk );
static STR_PARAM_PAGE_STACK * Page_PushPage( STR_PARAM_PAGE_STACK *p_wk, const STR_PARAM_PAGE *cp_page );
static STR_PARAM_PAGE_STACK * Page_PopPage( STR_PARAM_PAGE_STACK *p_wk );
static void Page_StoreData( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv );
static BOOL Page_ReStoreData( RESONANCE_RESORT_SV *p_resort_sv, const DEBUG_INPUT_WORK *cp_wk );
static BOOL Page_PushCallback( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv, u32 boxID );

//util

//--------------------------------------------------------------
/**
 *  Event
 */
//--------------------------------------------------------------
typedef struct
{
  GAMESYS_WORK      * gsys;
  FIELDMAP_WORK     * fieldmap;
  SAVE_CONTROL_WORK * ctrl;
  void              * p_sub_wk;
}DEBUG_INPUT_RESORT_DATA;
static GMEVENT_RESULT EVENT_DebugInputResort(GMEVENT * event, int *  seq, void * work);
GMEVENT * EVENT_CallDebugInputResort( GAMESYS_WORK *p_gsys, void *work )
{
  GMEVENT * event = GMEVENT_Create(p_gsys, NULL, EVENT_DebugInputResort, sizeof(DEBUG_INPUT_RESORT_DATA));
  DEBUG_INPUT_RESORT_DATA *p_wk = GMEVENT_GetEventWork(event);

  p_wk->gsys = p_gsys;
  p_wk->fieldmap = GAMESYSTEM_GetFieldMapWork(p_gsys);
  p_wk->ctrl = GAMEDATA_GetSaveControlWork(GAMESYSTEM_GetGameData(p_gsys));

  return event;
}

static GMEVENT_RESULT EVENT_DebugInputResort(GMEVENT * event, int *  seq, void * work)
{
  enum{
    _FIELD_COMM,
    _FIELD_FADEOUT,
    _FIELD_CLOSE,
    _CALL_WIFIBTLMATCH,
    _WAIT_WIFIBTLMATCH,
    _FIELD_OPEN,
    _FIELD_FADEIN,
    _FIELD_END
  };

  DEBUG_INPUT_RESORT_DATA * dbw = work;
  GAMESYS_WORK * gsys = dbw->gsys;


  switch (*seq) {
  case _FIELD_COMM:
      PMSND_PushBGM();
      (*seq)++;
    break;
  case _FIELD_FADEOUT:
    GMEVENT_CallEvent(event, EVENT_FieldFadeOut(gsys, dbw->fieldmap, FIELD_FADE_BLACK, FIELD_FADE_WAIT));
    (*seq)++;
    break;
  case _FIELD_CLOSE:
    GMEVENT_CallEvent(event, EVENT_FieldClose(gsys, dbw->fieldmap));
    (*seq)++;
    break;
  case _CALL_WIFIBTLMATCH:
    { 
      RESORT_DEBUG_INPUT_PARAM *p_param;
      dbw->p_sub_wk = GFL_HEAP_AllocClearMemory(HEAPID_PROC,sizeof(RESORT_DEBUG_INPUT_PARAM));
      p_param = dbw->p_sub_wk;
      p_param->p_gamedata = GAMESYSTEM_GetGameData( gsys );
      GAMESYSTEM_CallProc(gsys, GFL_OVERLAY_BLANK_ID, &DEBUG_INPUT_Resort_ProcData, dbw->p_sub_wk );
    }
    (*seq)++;
    break;
  case _WAIT_WIFIBTLMATCH:
    if (GAMESYSTEM_IsProcExists(gsys) == GFL_PROC_MAIN_NULL){
      GFL_HEAP_FreeMemory( dbw->p_sub_wk );
      (*seq) ++;
    }
    break;
    case _FIELD_OPEN:
    GMEVENT_CallEvent(event, EVENT_FieldOpen(gsys));
    (*seq) ++;
    break;
   case _FIELD_FADEIN:
    GMEVENT_CallEvent(event,EVENT_FieldFadeIn_Black(gsys, dbw->fieldmap, FIELD_FADE_WAIT ));
    (*seq) ++;
    break;
  case _FIELD_END:
    PMSND_PopBGM();
    return GMEVENT_RES_FINISH;
  default:
    GF_ASSERT(0);
    break;
  }
  return GMEVENT_RES_CONTINUE;
}

//--------------------------------------------------------------
/**
 *  Proc Data
 */
//--------------------------------------------------------------
const GFL_PROC_DATA DEBUG_INPUT_Resort_ProcData = {
  DEBUG_INPUT_Resort_Init,
  DEBUG_INPUT_Resort_Main,
  DEBUG_INPUT_Resort_Quit,
};

static GFL_PROC_RESULT DEBUG_INPUT_Resort_Init( GFL_PROC* proc, int* seq, void* pwk, void* mywk )
{
  RESORT_DEBUG_INPUT_PARAM *p_param  = pwk;

  DEBUG_RESORT_DATA_SetPermission( TRUE );

  //ヒープ作成
  GFL_HEAP_CreateHeap( GFL_HEAPID_APP, HEAPID_WIFIMATCH_DEBUG,   PROC_HEAP_SIZE );

  {
    DEBUG_INPUT_WORK* wk = GFL_PROC_AllocWork( proc, sizeof(DEBUG_INPUT_WORK), HEAPID_WIFIMATCH_DEBUG );
    GF_ASSERT(wk != NULL);
    GFL_STD_MemClear( wk, sizeof(DEBUG_INPUT_WORK));
    wk->Seq = 0;
    wk->HeapID = HEAPID_WIFIMATCH_DEBUG;
    wk->p_shop  = RESORT_BINARY_SHOP_Init(HEAPID_WIFIMATCH_DEBUG);
    wk->p_resort_sv = RESONANCE_RESORT_SV_GetWork( GAMEDATA_GetSaveControlWork(p_param->p_gamedata) );
    wk->p_gamedata  = p_param->p_gamedata;

    //初期ページ作成
    wk->p_pageData = Page_PushPage( NULL, &sc_first_page );

    SetupDisp( wk );
  }

  return GFL_PROC_RES_FINISH;
}

static GFL_PROC_RESULT DEBUG_INPUT_Resort_Main( GFL_PROC* proc, int* seq, void* pwk, void* mywk )
{
  DEBUG_INPUT_WORK* wk = mywk;

  if( MainCtrl(wk) ){
    return GFL_PROC_RES_FINISH;
  }

  return GFL_PROC_RES_CONTINUE;
}

static GFL_PROC_RESULT DEBUG_INPUT_Resort_Quit( GFL_PROC* proc, int* seq, void* pwk, void* mywk )
{
  DEBUG_INPUT_WORK* wk = mywk;

  CleanupDisp( wk );


  RESORT_BINARY_SHOP_Exit( wk->p_shop );
  GFL_PROC_FreeWork( proc );
  GFL_HEAP_DeleteHeap( HEAPID_WIFIMATCH_DEBUG );

  DEBUG_RESORT_DATA_SetPermission( FALSE );

  return GFL_PROC_RES_FINISH;
}

//----------------------------------------------------------------------------------
/**
 * 画面構築
 *
 * @param   wk
 */
//----------------------------------------------------------------------------------
static void SetupDisp( DEBUG_INPUT_WORK* wk )
{
  static const GFL_DISP_VRAM vramBank = {
    GX_VRAM_BG_128_A,           // メイン2DエンジンのBG
    GX_VRAM_BGEXTPLTT_NONE,     // メイン2DエンジンのBG拡張パレット
    GX_VRAM_SUB_BG_128_C,       // サブ2DエンジンのBG
    GX_VRAM_SUB_BGEXTPLTT_NONE, // サブ2DエンジンのBG拡張パレット
    GX_VRAM_OBJ_128_B,          // メイン2DエンジンのOBJ
    GX_VRAM_OBJEXTPLTT_NONE,    // メイン2DエンジンのOBJ拡張パレット
    GX_VRAM_SUB_OBJ_16_I,       // サブ2DエンジンのOBJ
    GX_VRAM_SUB_OBJEXTPLTT_NONE,// サブ2DエンジンのOBJ拡張パレット
    GX_VRAM_TEX_NONE,           // テクスチャイメージスロット
    GX_VRAM_TEXPLTT_NONE,       // テクスチャパレットスロット
    GX_OBJVRAMMODE_CHAR_1D_32K, // メインOBJマッピングモード
    GX_OBJVRAMMODE_CHAR_1D_32K, // サブOBJマッピングモード
  };

  GX_SetMasterBrightness(0);
  GXS_SetMasterBrightness(0);

  // BGsystem初期化
  GFL_BG_Init( wk->HeapID );
  {
    static const GFL_BG_SYS_HEADER sysHeader = {
      GX_DISPMODE_GRAPHICS, GX_BGMODE_0, GX_BGMODE_0, GX_BG0_AS_3D,
    };

    static const GFL_BG_BGCNT_HEADER bgcnt_m = {
      0, 0, 0x800, 0,
      GFL_BG_SCRSIZ_256x256, GX_BG_COLORMODE_16,
      GX_BG_SCRBASE_0x0000, GX_BG_CHARBASE_0x10000, 0x8000,
      GX_BG_EXTPLTT_01, 0, 0, 0, FALSE
    };

    static const GFL_BG_BGCNT_HEADER bgcnt_s = {
      0, 0, 0x800, 0,
      GFL_BG_SCRSIZ_256x256, GX_BG_COLORMODE_16,
      GX_BG_SCRBASE_0x0000, GX_BG_CHARBASE_0x10000, 0x8000,
      GX_BG_EXTPLTT_01, 0, 0, 0, FALSE
    };

    GFL_BG_SetBGMode( &sysHeader );
    GFL_BG_SetBGControl( PRINT_FRAME,   &bgcnt_m,   GFL_BG_MODE_TEXT );
    GFL_BG_SetBGControl( TEXT_FRAME,   &bgcnt_s,   GFL_BG_MODE_TEXT );

    GFL_BG_SetVisible( GFL_BG_FRAME0_M,   VISIBLE_OFF );
    GFL_BG_SetVisible( PRINT_FRAME,       VISIBLE_ON  );
    GFL_BG_SetVisible( TEXT_FRAME,       VISIBLE_ON  );
  }

  GFL_BMPWIN_Init( wk->HeapID );
  GFL_FONTSYS_Init();

  // VRAMバンク設定
  GFL_DISP_SetBank( &vramBank );

  // 各種効果レジスタ初期化
  G2_BlendNone();
  G2S_BlendNone();

  // 上下画面設定
  GX_SetDispSelect( GX_DISP_SELECT_SUB_MAIN );

  wk->Win = GFL_BMPWIN_Create( PRINT_FRAME, 0, 0, 32, 24, PRINT_PALIDX, GFL_BMP_CHRAREA_GET_F );
  wk->Bmp = GFL_BMPWIN_GetBmp( wk->Win );
  wk->Font = GFL_FONT_Create( ARCID_FONT, NARC_font_small_gftr, GFL_FONT_LOADTYPE_FILE, FALSE, wk->HeapID );
  wk->MsgData = GFL_MSG_Create( GFL_MSG_LOAD_NORMAL, ARCID_DEBUG_MESSAGE, NARC_debug_message_debug_resort_dat, wk->HeapID );
  wk->StrBuf = GFL_STR_CreateBuffer( STRBUF_LEN, wk->HeapID );

  {
    int i;
    for( i = 0; i < EDITBOX_ID_STR_MAX; ++i )
    {
      wk->BoxStrBuf[i] = GFL_STR_CreateBuffer( 64, wk->HeapID );
    }
  }
  wk->PrintQue = PRINTSYS_QUE_Create( wk->HeapID );
  PRINT_UTIL_Setup( &wk->PrintUtil, wk->Win );


  GFL_ARC_UTIL_TransVramPalette( ARCID_FONT, NARC_font_default_nclr, PALTYPE_MAIN_BG, 0, 0, wk->HeapID );
  GFL_ARC_UTIL_TransVramPalette( ARCID_FONT, NARC_font_default_nclr, PALTYPE_SUB_BG, 0, 0, wk->HeapID );
  GFL_BMP_Clear( wk->Bmp, 0x0f );
  GFL_BMPWIN_MakeScreen( wk->Win );
  GFL_BG_LoadScreenReq( PRINT_FRAME );

  GFL_BMPWIN_TransVramCharacter( wk->Win );


}
//----------------------------------------------------------------------------------
/**
 * 画面クリーンアップ
 *
 * @param   wk
 */
//----------------------------------------------------------------------------------
static void CleanupDisp( DEBUG_INPUT_WORK* wk )
{
  PRINTSYS_QUE_Delete( wk->PrintQue );


  {
    int i;
    for( i = 0; i < EDITBOX_ID_STR_MAX; ++i )
    {
      GFL_STR_DeleteBuffer( wk->BoxStrBuf[i] );
    }
  }
  GFL_STR_DeleteBuffer( wk->StrBuf );
  GFL_MSG_Delete( wk->MsgData );
  GFL_FONT_Delete( wk->Font );
  GFL_BMPWIN_Delete( wk->Win );
  GFL_BMPWIN_Exit();
  GFL_BG_Exit();
}

//----------------------------------------------------------------------------------
/**
 * 操作ルート
 *
 * @param   wk
 *
 * @retval  BOOL    終わったらTRUE
 */
//----------------------------------------------------------------------------------
static BOOL MainCtrl( DEBUG_INPUT_WORK* wk )
{
  if( PRINT_UTIL_Trans(&wk->PrintUtil, wk->PrintQue) )
  {
    const STR_PARAM_DISPLAY *cp_display = Page_GetStrParamDisplay( wk->p_pageData );

    switch( wk->Seq ){
    case SEQ_DRAW_CAPTION:
      {
        int i;
        for(i=0; i<cp_display->len; ++i){
          PrintCaption( wk, &cp_display->strParams[i] );
        }
      }
      wk->Seq = SEQ_DRAW_BOX;
      break;      
    case SEQ_DRAW_BOX:
      {
        int i;
        for(i=0; i<cp_display->len; ++i){
          if( cp_display->strParams[i].Type == STR_TYPE_EDITSTR )
          {
            UpdateStrBox( wk, cp_display->strParams[i].editBoxID);
          }
          else
          {
            UpdateBox( wk, cp_display->strParams[i].editBoxID, wk->BoxValue[ cp_display->strParams[i].editBoxID ] );
          }
        }
        wk->Seq = SEQ_WAIT_CTRL;
      }
      break;      
    case SEQ_WAIT_CTRL:
      //ページ更新
      {
        BOOL is_update  = FALSE;
        if( GFL_UI_KEY_GetTrg() == PAD_BUTTON_L )
        {
          Page_PrevPage( wk->p_pageData );
          is_update = TRUE;
        }
        if( GFL_UI_KEY_GetTrg() == PAD_BUTTON_R )
        {
          Page_NextPage( wk->p_pageData );
          is_update = TRUE;
        }
        if( is_update )
        {
          wk->Seq = SEQ_REDRAW;
          break;
        }
      }
      //キー操作
      {
        u16 key = GFL_UI_KEY_GetTrg();
        if( key & PAD_BUTTON_A )
        {
          Page_ReStoreData( wk->p_resort_sv, wk );
          key |= PAD_BUTTON_B;
        }

        if( key & PAD_BUTTON_B )
        {
          wk->p_pageData = Page_PopPage( wk->p_pageData );
          if( wk->p_pageData == NULL )
          {
            //アプリ終了
            return TRUE;
          }
          else
          {
            wk->Seq = SEQ_REDRAW;
            break;
          }
        }
      }

      //ボックスタッチ待ち
      wk->BoxIdx = CheckBoxTouch( wk );
      if( wk->BoxIdx >= 0 )
      {
        const STR_PARAM* p  = NULL;

        p = GetBoxForEditBoxID( wk, wk->BoxIdx );
        
        if( p == NULL ) break;

        switch( p->Type ){
        case STR_TYPE_STR:
        case STR_TYPE_EDITSTR:  
          {            
            static const GFL_SKB_SETUP setup = {
              STRBUF_LEN, GFL_SKB_STRTYPE_STRBUF,
              GFL_SKB_MODE_KATAKANA, TRUE, 0, PAD_BUTTON_START,
              PRINT_FRAME, SKB_PALIDX1, SKB_PALIDX2,
            };
            wk->skbSetup = setup;
            GetBoxStr( wk, wk->BoxIdx, wk->StrBuf );
            if( is_hiragana(wk->StrBuf) ){
              wk->skbSetup.mode = GFL_SKB_MODE_HIRAGANA;
            }
            wk->skb = GFL_SKB_Create( (void*)(wk->StrBuf), &wk->skbSetup, wk->HeapID );
            COMPSKB_Setup( &wk->comp, wk->skb, wk->StrBuf, p->arg, wk->HeapID );
            wk->Seq = SEQ_INPUT_STR;            
          }
          break;
        case STR_TYPE_NUM:
          NumInput_Setup( &wk->NumInput, wk->StrBuf, wk->Win, wk->Font,
              &wk->PrintUtil, wk->PrintQue, p, wk->BoxValue[wk->BoxIdx], 0,wk, NUMINPUT_TYPE_DECIMAL );
          wk->Seq = SEQ_INPUT_NUM;
          break;          
        case STR_TYPE_BIT:
          NumInput_Setup( &wk->NumInput, wk->StrBuf, wk->Win, wk->Font,
              &wk->PrintUtil, wk->PrintQue, p, wk->BoxValue[wk->BoxIdx], p->arg, wk, NUMINPUT_TYPE_BIT );
          wk->Seq = SEQ_INPUT_NUM;
          break;
        case STR_TYPE_SWITCH:
          {
            u32 val = wk->BoxValue[wk->BoxIdx];

            if( wk->touch_prev_flag ){
              if( val == 0 ){
                val = p->arg2-1;
              }
              else
              {
                --val;
              }
            }else{
              if( ++val >= p->arg2 ){
                val = 0;
              }
            }

            UpdateBox( wk, wk->BoxIdx, val );
          }
          break;
        case STR_TYPE_BUTTON:
          {
            ButtonAction_Callback action  = (ButtonAction_Callback)p->arg2;
            if( action != NULL )
            {
              action( wk, p );
            }
          }
          break;
        }       //end switch
        break;
      }
      break;
    case SEQ_INPUT_STR:      
      if( COMPSKB_Main(&wk->comp) )
      {
        int idx;
        const STR_PARAM* p;
        p = GetBoxForEditBoxID( wk, wk->BoxIdx );
        if( p == NULL ) break;

        if ( p->Type == STR_TYPE_EDITSTR)
        {

          const u32 strBoxID  = p->editBoxID - EDITBOX_ID_MAX;
          GF_ASSERT( p->editBoxID >= EDITBOX_ID_MAX);

          if( GFL_STR_GetBufferLength(wk->StrBuf) == 0 ){
            idx = 0;
          }
          GFL_STR_CopyBuffer( wk->BoxStrBuf[ strBoxID ], wk->StrBuf );
          idx = 0;
          UpdateStrBox( wk, wk->BoxIdx);
        }
        else
        {
          idx = COMPSKB_GetWordIndex( &wk->comp );
          if( idx < 0 ){
            if( GFL_STR_GetBufferLength(wk->StrBuf) == 0 ){
              idx = 0;
            }
          }
          if( idx >= 0 ){
            UpdateBox( wk, wk->BoxIdx, idx );
          }
        }
        COMPSKB_Cleanup( &wk->comp );
        GFL_SKB_Delete( wk->skb );
        wk->Seq = SEQ_WAIT_CTRL;
      }      
      break;
    case SEQ_INPUT_NUM:
      if( NumInput_Main(&wk->NumInput) )
      {
        u32 num = NumInput_GetNum( &wk->NumInput );
        OS_TPrintf( "num_input %d\n", num );
        UpdateBox( wk, wk->BoxIdx, num );
        wk->Seq = SEQ_WAIT_CTRL;
      }
      break;

    case SEQ_REDRAW:
      wk->Seq = SEQ_DRAW_CAPTION;
      GFL_BMP_Clear( wk->Bmp, 0x0f );
      break;
    }    //end switch
  } //end if
  return FALSE;
}

//----------------------------------------------------------------------------------
/**
 * 項目名描画
 *
 * @param   wk
 * @param   p
 */
//----------------------------------------------------------------------------------
static void PrintCaption( DEBUG_INPUT_WORK* wk, const STR_PARAM* p )
{
  if( p->StrID != CAPTION_NONE ){
    u32 ypos = p->PosY/* + ((LINE_HEIGHT - GFL_FONT_GetLineHeight(wk->Font)) / 2)*/;
    GFL_MSG_GetString( wk->MsgData, p->StrID, wk->StrBuf );
    PRINT_UTIL_Print( &wk->PrintUtil, wk->PrintQue, p->PosX, ypos, wk->StrBuf, wk->Font );
  }
}

static int CheckBoxTouch( DEBUG_INPUT_WORK* wk )
{
  u32 x, y;
  if( GFL_UI_TP_GetPointTrg( &x, &y ) )
  {
    const STR_PARAM_DISPLAY *cp_display = Page_GetStrParamDisplay( wk->p_pageData );

    u32 i;
    for(i=0; i<cp_display->len; ++i)
    {
      const STR_PARAM* p = &cp_display->strParams[i];
      if( p->Type != STR_TYPE_CAPTION && p->Type != STR_TYPE_FIXNUM )
      {
        if( (x >= p->TouchX) && (x <= (p->TouchX + p->TouchW))
            &&  (y >= p->TouchY) && (y <= (p->TouchY + p->TouchH))
          ){
          u32 x_center = p->TouchX + (p->TouchW / 2);
          wk->touch_prev_flag = ( x < x_center );
          return p->editBoxID;
        }
      }
    }
  }
  return -1;
}

static void UpdateBox( DEBUG_INPUT_WORK* wk, u32 inBoxID, u32 inValue )
{
  const STR_PARAM* p  = NULL;
  u32 str_width, str_height, xpos, ypos;
  PRINTSYS_LSB color;
  u8 color_bg;

  p = GetBoxForEditBoxID( wk, inBoxID );
  if( p == NULL ) return;
  if ( p->Type == STR_TYPE_EDITSTR ) return;
  if(  p->Type == STR_TYPE_CAPTION ) return;

  color = GetBoxSubBGColor( p->Type );
  color_bg = PRINTSYS_LSB_GetB( color );

  GFL_BMP_Fill( wk->Bmp, p->TouchX, p->TouchY, p->TouchW, p->TouchH, color_bg );

  wk->BoxValue[ inBoxID ] = inValue;
  GetBoxStr( wk, inBoxID, wk->StrBuf );

  str_width = PRINTSYS_GetStrWidth( wk->StrBuf, wk->Font, 0 );
  xpos = p->TouchX;
  if( str_width < p->TouchW ){
    xpos += (p->TouchW - str_width) / 2;
  }
  str_height = GFL_FONT_GetLineHeight( wk->Font );
  ypos = p->TouchY;

  PRINT_UTIL_PrintColor( &wk->PrintUtil, wk->PrintQue, xpos, ypos, wk->StrBuf, wk->Font, color );

  Page_PushCallback( wk, wk->p_resort_sv, inBoxID );
}

static void UpdateBoxInner( DEBUG_INPUT_WORK* wk, u32 inBoxID, u32 inValue )
{
  const STR_PARAM* p  = NULL;
  u32 str_width, str_height, xpos, ypos;
  PRINTSYS_LSB color;
  u8 color_bg;

  p = GetBoxForEditBoxID( wk, inBoxID );
  if( p == NULL ) return;
  if ( p->Type == STR_TYPE_EDITSTR ) return;
  if(  p->Type == STR_TYPE_CAPTION ) return;

  color = GetBoxSubBGColor( p->Type );
  color_bg = PRINTSYS_LSB_GetB( color );

  GFL_BMP_Fill( wk->Bmp, p->TouchX, p->TouchY, p->TouchW, p->TouchH, color_bg );

  wk->BoxValue[ inBoxID ] = inValue;
  GetBoxStr( wk, inBoxID, wk->StrBuf );

  str_width = PRINTSYS_GetStrWidth( wk->StrBuf, wk->Font, 0 );
  xpos = p->TouchX;
  if( str_width < p->TouchW ){
    xpos += (p->TouchW - str_width) / 2;
  }
  str_height = GFL_FONT_GetLineHeight( wk->Font );
  ypos = p->TouchY;

  PRINT_UTIL_PrintColor( &wk->PrintUtil, wk->PrintQue, xpos, ypos, wk->StrBuf, wk->Font, color );
}

static void UpdateStrBox( DEBUG_INPUT_WORK* wk, u32 inBoxID)
{
  const STR_PARAM* p;
  u32 str_width, str_height, xpos, ypos;
  PRINTSYS_LSB color;
  u8 color_bg;
  const u32 strBoxID  = inBoxID - EDITBOX_ID_MAX;

  GF_ASSERT( inBoxID >= EDITBOX_ID_MAX);

  p = GetBoxForEditBoxID( wk, inBoxID );
  if( p == NULL ) return;
  if( p->Type != STR_TYPE_EDITSTR ) return;

  color = GetBoxSubBGColor( p->Type );
  color_bg = PRINTSYS_LSB_GetB( color );

  GFL_BMP_Fill( wk->Bmp, p->TouchX, p->TouchY, p->TouchW, p->TouchH, color_bg );

  str_width = PRINTSYS_GetStrWidth( wk->BoxStrBuf[ strBoxID ], wk->Font, 0 );
  xpos = p->TouchX;
  if( str_width < p->TouchW ){
    xpos += (p->TouchW - str_width) / 2;
  }
  str_height = GFL_FONT_GetLineHeight( wk->Font );
  ypos = p->TouchY;

  PRINT_UTIL_PrintColor( &wk->PrintUtil, wk->PrintQue, xpos, ypos, wk->BoxStrBuf[ strBoxID ], wk->Font, color );

  Page_PushCallback( wk, wk->p_resort_sv, inBoxID );
}


static PRINTSYS_LSB GetBoxSubBGColor( u8 inType )
{
  switch( inType ){
  case STR_TYPE_STR:     return PRINTSYS_LSB_Make( COLIDX_BLACK, 0, COLIDX_ORANGE_D );
  case STR_TYPE_NUM:     return PRINTSYS_LSB_Make( COLIDX_BLACK, 0, COLIDX_BLUE_L );
  case STR_TYPE_SWITCH:  return PRINTSYS_LSB_Make( COLIDX_BLACK, 0, COLIDX_GREEN_L );
  case STR_TYPE_EDITSTR: return PRINTSYS_LSB_Make( COLIDX_BLACK, 0, COLIDX_ORANGE_D );
  case STR_TYPE_FIXNUM:  return PRINTSYS_LSB_Make( COLIDX_WHITE, 0, COLIDX_GRAY );
  case STR_TYPE_BUTTON:  return PRINTSYS_LSB_Make( COLIDX_BLACK, 0, COLIDX_RED_L );
  case STR_TYPE_BIT:     return PRINTSYS_LSB_Make( COLIDX_BLACK, 0, COLIDX_BLUE_D );
  }
  return PRINTSYS_LSB_Make( COLIDX_BLACK, 0, COLIDX_WHITE );
}

static void GetBoxStr( DEBUG_INPUT_WORK* wk, u32 inBoxID, STRBUF* buf )
{
  const STR_PARAM* p  = NULL;
  u32 value = wk->BoxValue[ inBoxID ];
  p = GetBoxForEditBoxID( wk, inBoxID );

  if( p == NULL ) return;


  switch( p->Type ){
  case STR_TYPE_STR:
    {
      GFL_MSGDATA* msgdat = GFL_MSG_Create( GFL_MSG_LOAD_NORMAL, ARCID_MESSAGE, p->arg, GFL_HEAP_LOWID(wk->HeapID) );
      GFL_MSG_GetString( msgdat, value, wk->StrBuf );
      GFL_MSG_Delete( msgdat );
    }
    break;
  case STR_TYPE_EDITSTR:
    {
      const u32 strBoxID  = inBoxID - EDITBOX_ID_MAX;
      GF_ASSERT( inBoxID >= EDITBOX_ID_MAX);
      GFL_STR_CopyBuffer( wk->StrBuf, wk->BoxStrBuf[ strBoxID ] );
    }
    break;
  case STR_TYPE_NUM:
    {
      u8 keta = 1;
      keta = CalcDisit(p->arg);
      STRTOOL_SetUnsignedNumber( wk->StrBuf, value, keta, STR_NUM_DISP_SPACE, STR_NUM_CODE_ZENKAKU );
    }
    break;
  case STR_TYPE_SWITCH:
    GFL_MSG_GetString( wk->MsgData, p->arg+value, wk->StrBuf );
    break;    
  case STR_TYPE_FIXNUM:
    STRTOOL_SetUnsignedNumber( wk->StrBuf, value, CalcDisit(p->arg), STR_NUM_DISP_SPACE, STR_NUM_CODE_ZENKAKU );
    break;
  case STR_TYPE_BUTTON:
    GFL_MSG_GetString( wk->MsgData, p->arg, wk->StrBuf );
    break;
  case STR_TYPE_BIT:
    {
      enum
      {
        n0_ = 0xff10,
      };
      int i;
      u8 keta = p->arg;
      u32 temp[32];
      u64 v;
      //２進数に変換
      v = Calc10To2( value, keta );

      for( i = 0; i < keta; i++ )
      {
        temp[i] = v % 10;
        v /= 10;
      }

      GFL_STR_ClearBuffer( wk->StrBuf );
      //むりやり表示するためにやっちゃいけないことをしているがデバッグ版なのでよしとする
      for( i = keta-1; i >= 0; i-- )
      {
        GFL_STR_AddCode( wk->StrBuf, n0_+temp[i] );
      }

    }
    break;
  } //end switch  
}

static u32 CalcDisit( u32 inValue )
{
  u64 max;
  u32 disit;

  disit = 1;
  max = 10;
  while( 1 )
  {
    if( inValue < max ){ break; }
    max *= 10;
    ++disit;
  }
  return disit;
}
static u64 Calc10To2( u32 in10, u32 keta )
{
  int i;
  BOOL bit;
  u64 pow = 1;
  u64 ans = 0;
  for( i = 0; i < keta; i++, pow *= 10 )
  {
    bit = (in10 & 1<<i) != 0;
    ans += bit * pow;
  }

  OS_TPrintf( "[10]=%d [2]=%d\n", in10, ans );

  return ans;
}
static u32 Calc2To10( u64 in2, u32 keta )
{
  int temp[32];
  int i;
  int pow = 1;
  int ans = 0;

  GF_ASSERT(keta < 32);
  OS_TPrintf( "[2]=%d ", in2 );
  for( i = 0; i < keta; i++ )
  {
    temp[i] = in2 % 10;
    in2 /= 10;
  }

  for( i = 0; i < keta; i++, pow *= 2 )
  {
    ans += temp[i] * pow;
  }

  OS_TPrintf( "[10]=%d\n", ans );

  return ans;
}

static const STR_PARAM *GetBoxForEditBoxID( const DEBUG_INPUT_WORK* wk, u32 inBoxID )
{
  const STR_PARAM* p  = NULL;
  int i;
  const STR_PARAM_DISPLAY *cp_display = Page_GetStrParamDisplay( wk->p_pageData );

  for(i=0; i<cp_display->len; ++i)
  {
    if( cp_display->strParams[i].editBoxID == inBoxID )
    {
      p = &cp_display->strParams[i];
    }
  }

  return p;
}


//---------------------数値入力---------------------------------------------------------------------


//==============================================================================================
//  数値入力処理
//==============================================================================================
static void NumInput_Setup( NUMINPUT_WORK* wk, STRBUF* buf, GFL_BMPWIN* win, GFL_FONT* font, PRINT_UTIL* util, PRINT_QUE* que, const STR_PARAM* strParam, u32 value, u32 keta, const DEBUG_INPUT_WORK* make_wk, NUMINPUT_TYPE type )
{
  PRINTSYS_LSB color = GetBoxSubBGColor( strParam->Type );

  wk->type = type;
  wk->Win = win;
  wk->Bmp = GFL_BMPWIN_GetBmp( win );
  wk->Font = font;
  wk->Buf = buf;
  wk->PrintUtil = util;
  wk->PrintQue = que;
  wk->Param = strParam;

  wk->Draw_ox = strParam->TouchX + NUMBOX_MARGIN;
  wk->ColorDefBg = PRINTSYS_LSB_GetB( color );
  wk->ColorCurBg = COLIDX_RED_L;
  wk->ColorLetter = PRINTSYS_LSB_GetL( color );

  wk->DispNumWork = value;
  wk->CurDisit = 0;

  switch( wk->type )
  {
  case NUMINPUT_TYPE_DECIMAL:
    SetAryNumInput( wk, value );
    wk->NumMax = strParam->arg;
    wk->NumMin = strParam->arg2;
    wk->Num = value;
    wk->Disit = CalcDisit( wk->NumMax );
    break;
  case NUMINPUT_TYPE_BIT:
    wk->NumMax = 0xFFFFFFFF;
    wk->NumMin = 0;
    wk->Disit = keta;
    wk->Num = value;
    SetAryNumInput( wk, value );
    break;
  }

  DrawNumInput( wk );
}
static BOOL NumInput_Main( NUMINPUT_WORK* wk )
{
  u32 x,y;
  u16 key = GFL_UI_KEY_GetTrg();

  if( (key & PAD_BUTTON_A)|| GFL_UI_TP_GetPointTrg( &x, &y ) ){
    switch( wk->type )
    {
    case NUMINPUT_TYPE_DECIMAL:
      wk->Num = CalcInputNum( wk );
      break;
    case NUMINPUT_TYPE_BIT:
      wk->Num = Calc2To10( CalcInputNum( wk ), wk->Disit );
      break;
    }
    return TRUE;
  }
  if( key & PAD_BUTTON_B ){
    return TRUE;
  }

  {
    u8 update = TRUE;
    u8 up_key_flg = FALSE;
    do {
      if( key & PAD_KEY_LEFT ){
        if( wk->CurDisit < (wk->Disit-1) ){
          wk->CurDisit++;
          break;
        }
      }
      if( key & PAD_KEY_RIGHT ){
        if( wk->CurDisit > 0 ){
          wk->CurDisit--;
          break;
        }
      } 
      if( wk->type == NUMINPUT_TYPE_DECIMAL )
      {
        if( key & PAD_KEY_UP )
        {
          int k = wk->CurDisit;
          while( k < (wk->Disit) ){
            wk->NumAry[k]++;
            if( wk->NumAry[k] <= 9 ){ break; }
            wk->NumAry[k] = 0;
            ++k;
          }
          // 桁あふれしたら最大値に
          if( k == (wk->Disit) ){
            OS_Printf("↑　ケタあふれ\n");
            SetAryNumInput( wk, wk->NumMax );
          }
          //上キー押下チェックON
          up_key_flg = TRUE;
          break;
        }
        if( key & PAD_KEY_DOWN )
        {
          int k = wk->CurDisit;
          while( k < (wk->Disit) )
          {
            wk->NumAry[k]--;
            if( wk->NumAry[k] >= 0 ){ break; }
            wk->NumAry[k] = 9;
            ++k;
          }
          // 桁あふれしたら最小値に
          if( k == (wk->Disit) ){
            OS_Printf("↓　ケタあふれ\n");
            SetAryNumInput( wk, wk->NumMin );
          }
          break;
        }
        if( key & PAD_BUTTON_L ){
          SetAryNumInput( wk, wk->NumMax );
          break;
        }
        if( key & PAD_BUTTON_R ){
          SetAryNumInput( wk, wk->NumMin );
          break;
        }
      }
      else if( wk->type == NUMINPUT_TYPE_BIT )
      {
        if( key & PAD_KEY_UP
            || key & PAD_KEY_DOWN )
        {
          int k = wk->CurDisit;
          wk->NumAry[k] ^= 1;
          //上キー押下チェックON
          break;
        }
      }
      update = FALSE;
    }while(0);

    if( update ){
      u32 num = CalcInputNum( wk );

      //数値加算したのに値が下回ったをチェック（値のオーバーフローチェック）
      if ( up_key_flg )
      {
        if (num < wk->DispNumWork)
        {
          num = wk->NumMax;
          SetAryNumInput( wk, num );
        }
      }

      if( num > wk->NumMax ){
        num = wk->NumMax;
        SetAryNumInput( wk, num );
      }
      if( num < wk->NumMin ){
        num = wk->NumMin;
        SetAryNumInput( wk, num );
      }
      DrawNumInput( wk );
      wk->DispNumWork = num;
    }
  }
  return FALSE;
}
static u32 NumInput_GetNum( NUMINPUT_WORK* wk )
{
  return wk->Num;
}
static void DrawNumInput( NUMINPUT_WORK* wk )
{
  const STR_PARAM* p = wk->Param;

  GFL_BMP_Fill( wk->Bmp, p->TouchX, p->TouchY, p->TouchW, p->TouchH, wk->ColorDefBg );
  {
    int i;
    u32 xpos = wk->Draw_ox;
    u32 ypos = p->TouchY;
    PRINTSYS_LSB color;
    u8 col_bg;

    for(i=wk->Disit-1; i>=0; --i)
    {
      col_bg = (i==wk->CurDisit)? wk->ColorCurBg : wk->ColorDefBg;
      color = PRINTSYS_LSB_Make( wk->ColorLetter, 0, col_bg );
      STRTOOL_SetUnsignedNumber( wk->Buf, wk->NumAry[i], 1, STR_NUM_DISP_LEFT, STR_NUM_CODE_ZENKAKU );
      GFL_BMP_Fill( wk->Bmp, xpos, p->TouchY, NUMBOX_CHAR_WIDTH, p->TouchH, col_bg );
      PRINT_UTIL_PrintColor( wk->PrintUtil, wk->PrintQue, xpos, ypos, wk->Buf, wk->Font, color );
      xpos += NUMBOX_CHAR_WIDTH;
      GFL_BMPWIN_TransVramCharacter( wk->Win );
    }
  }
}
static void SetAryNumInput( NUMINPUT_WORK* wk, u32 value )
{
#if 0
  u32 k = 1000000000;
  u32 i = NUMINPUT_DISIT_MAX-1;

  GFL_STD_MemClear( wk->NumAry, sizeof(wk->NumAry) );
  while(i){
    wk->NumAry[i] = value / k;
    value -= (wk->NumAry[i] * k);
    k /= 10;
    i--;
  }
  wk->NumAry[i] = value;
#endif
  int i = 0;
  u64 v;

  if( wk->type == NUMINPUT_TYPE_DECIMAL )
  {
    v = value;
  }
  else if( wk->type == NUMINPUT_TYPE_BIT )
  {
    v = Calc10To2( value, 32 );
  }

  GFL_STD_MemClear( wk->NumAry, sizeof(wk->NumAry) );
  while( v )
  {
    wk->NumAry[i] = v % 10;
    v /= 10;
    i++;
  }
}
static u64 CalcInputNum( NUMINPUT_WORK* wk )
{
  u32 i;
  u64 k;
  u64 num;
  num = 0;
  for(i=0, k=1; i<wk->Disit; ++i, k*=10)
  {
    num += ( wk->NumAry[i] * k );
  }
  return num;
}




//==============================================================================================
//  入力補完処理
//==============================================================================================
static void COMPSKB_Setup( COMP_SKB_WORK* wk, GFL_SKB* skb, STRBUF* buf, u32 msgDataID, HEAPID heapID )
{
  wk->skb = skb;
  wk->msg = GFL_MSG_Create( GFL_MSG_LOAD_FAST, ARCID_MESSAGE, msgDataID, heapID );
  wk->buf = buf;
  wk->subword  = GFL_STR_CreateBuffer( 64, heapID );
  wk->fullword = GFL_STR_CreateBuffer( 64, heapID );
  wk->index = -1;
  wk->search_first_index = -1;
  wk->searchingFlag = FALSE;
}
static void COMPSKB_Cleanup( COMP_SKB_WORK* wk )
{
  GFL_STR_DeleteBuffer( wk->fullword );
  GFL_STR_DeleteBuffer( wk->subword );
  GFL_MSG_Delete( wk->msg );
}

static BOOL COMPSKB_Main( COMP_SKB_WORK* wk )
{
  GflSkbReaction reaction = GFL_SKB_Main( wk->skb );
  BOOL fSearchReq = FALSE;

  if( reaction != GFL_SKB_REACTION_NONE
  &&  reaction != GFL_SKB_REACTION_PAGE ){
    wk->searchingFlag = FALSE;
  }

  switch( reaction ){

  case GFL_SKB_REACTION_QUIT:
    if( wk->index == -1 )
    {
      int idx;
      GFL_SKB_PickStr( wk->skb );
      if( comskb_is_match(wk, wk->buf, &idx) ){
        wk->index = idx;
      }
    }
    return TRUE;
  case GFL_SKB_REACTION_INPUT:
    {
      int idx;
      GFL_SKB_PickStr( wk->skb );
      if( compskb_search(wk, wk->buf, -1, &idx) == 1 )
      {
        GFL_MSG_GetString( wk->msg, idx, wk->fullword );
        GFL_SKB_ReloadStr( wk->skb, wk->fullword );
        wk->index = idx;
      }
      else{
        wk->index = -1;
      }
    }
    break;
  case GFL_SKB_REACTION_BACKSPACE:
    {
      int idx;
      GFL_SKB_PickStr( wk->skb );
      if( compskb_search(wk, wk->buf, -1, &idx) == 1 ){
        wk->index = idx;
      }else{
        wk->index = -1;
      }
    }
    break;
  case GFL_SKB_REACTION_PAGE:
    fSearchReq = TRUE;
    break;
  case GFL_SKB_REACTION_NONE:
    {
      u16 key = GFL_UI_KEY_GetTrg();
      if( key & PAD_BUTTON_SELECT ){
        fSearchReq = TRUE;
      }
    }
    break;
  }

  if( fSearchReq )
  {
    if( wk->searchingFlag == FALSE ){
      GFL_SKB_PickStr( wk->skb );
      GFL_STR_CopyBuffer( wk->subword, wk->buf );
      wk->search_first_index = -1;
      wk->index = -1;
      wk->searchingFlag = TRUE;
    }
    {
      int idx;
      if( compskb_search(wk, wk->subword, wk->index, &idx) )
      {
        wk->index = idx;
        if( wk->search_first_index == -1 ){
          wk->search_first_index = idx;
        }
      }
      else
      {
        wk->index = wk->search_first_index;
      }

      if( wk->index != -1 )
      {
        GFL_MSG_GetString( wk->msg, wk->index, wk->fullword );
        GFL_SKB_ReloadStr( wk->skb, wk->fullword );
      }

    }
  }

  return FALSE;
}
static int COMPSKB_GetWordIndex( const COMP_SKB_WORK* wk )
{
  return wk->index;
}
static BOOL compskb_strncmp( const STRBUF* str1, const STRBUF* str2, u32 len )
{
  if( GFL_STR_GetBufferLength(str1) < len ){
    return FALSE;
  }
  if( GFL_STR_GetBufferLength(str2) < len ){
    return FALSE;
  }

  {
    const STRCODE *p1 = GFL_STR_GetStringCodePointer( str1 );
    const STRCODE *p2 = GFL_STR_GetStringCodePointer( str2 );
    u32 i;
    for(i=0; i<len; ++i){
      if( *p1++ != *p2++ ){ return FALSE; }
    }
    return TRUE;
  }
  return FALSE;
}
//----------------------------------------------------------------------------------
/**
 * 前方一致する文字列数をサーチ
 *
 * @param   wk
 * @param   word
 * @param   org_idx
 * @param   first_idx   [out] 最初に一致した文字列index
 *
 * @retval  u32   前方一致する文字列数
 */
//----------------------------------------------------------------------------------
static u32 compskb_search( COMP_SKB_WORK* wk, const STRBUF* word, int org_idx, int* first_idx )
{
  u32 word_len = GFL_STR_GetBufferLength( word );
  if( word_len )
  {
    u32 str_cnt, match_cnt, i;

    *first_idx = -1;
    match_cnt = 0;
    str_cnt = GFL_MSG_GetStrCount( wk->msg );
    i = (org_idx < 0)? 0 : org_idx+1;
    while( i < str_cnt )
    {
      GFL_MSG_GetString( wk->msg, i, wk->fullword );
      if( compskb_strncmp( word, wk->fullword, GFL_STR_GetBufferLength(word) ) ){
        if( *first_idx == -1 ){
          *first_idx = i;
        }
        ++match_cnt;
      }
      ++i;
    }
    return match_cnt;
  }
  return 0;
}
//----------------------------------------------------------------------------------
/**
 * 完全一致する文字列をサーチ
 *
 * @param   wk
 * @param   word
 * @param   match_idx   [OUT] 完全一致した文字列index
 *
 * @retval  BOOL    完全一致が見つかればTRUE
 */
//----------------------------------------------------------------------------------
static BOOL comskb_is_match( COMP_SKB_WORK* wk, const STRBUF* word, int* match_idx )
{
  u32 word_len = GFL_STR_GetBufferLength( word );
  if( word_len )
  {
    u32 str_cnt, i=0;

    str_cnt = GFL_MSG_GetStrCount( wk->msg );
    while( i < str_cnt )
    {
      GFL_MSG_GetString( wk->msg, i, wk->fullword );
      if( GFL_STR_CompareBuffer(word, wk->fullword) ){
        *match_idx = i;
        return TRUE;
      }
      ++i;
    }
  }
  return FALSE;
}

static BOOL is_hiragana( const STRBUF* buf )
{
  const STRCODE* ptr;
  ptr = GFL_STR_GetStringCodePointer( buf );
  if( (*ptr >= 0x3041) && (*ptr <= 0x3093) ){
    return TRUE;
  }
  return FALSE;
}

//=============================================================================
/**
 *  BUTTONのアクションコールバック
 */
//=============================================================================
static void ButtonAction_First_Add( DEBUG_INPUT_WORK *wk, const STR_PARAM *StrParam )
{
  switch( wk->BoxValue[EDITBOX_ID_FIRST_PEOPLE] )
  {
  case 0: //街
    wk->p_pageData  = Page_PushPage( wk->p_pageData, &sc_city_page );
    break;
  case 1: //店配置
    wk->p_pageData  = Page_PushPage( wk->p_pageData, &sc_shoppos_page );
    break;
  case 2: //住民
    wk->p_pageData  = Page_PushPage( wk->p_pageData, &sc_resident_page );
    break;
  case 3: //旅行者
    wk->p_pageData  = Page_PushPage( wk->p_pageData, &sc_tourist_page );
    break;
  case 4: //自分
    wk->p_pageData  = Page_PushPage( wk->p_pageData, &sc_owner_page );
    break;
  case 5: //デバッグ入力
    wk->p_pageData  = Page_PushPage( wk->p_pageData, &sc_debug_flag_page );
    break;
  default:
    GF_ASSERT(0);
  }
  wk->modify_type = DATA_MODIRY_TYPE_ADD;
  Page_StoreData( wk, wk->p_resort_sv );
  wk->Seq = SEQ_REDRAW;
}

static void ButtonAction_First_Change( DEBUG_INPUT_WORK *wk, const STR_PARAM *StrParam )
{
  switch( wk->BoxValue[EDITBOX_ID_FIRST_PEOPLE] )
  {
  case 0: //街
    wk->p_pageData  = Page_PushPage( wk->p_pageData, &sc_city_page );
    break;
  case 1: //店配置
    wk->p_pageData  = Page_PushPage( wk->p_pageData, &sc_shoppos_page );
    break;
  case 2: //住民
    wk->p_pageData  = Page_PushPage( wk->p_pageData, &sc_resident_page );
    break;
  case 3: //旅行者
    wk->p_pageData  = Page_PushPage( wk->p_pageData, &sc_tourist_page );
    break;
  case 4: //自分
    wk->p_pageData  = Page_PushPage( wk->p_pageData, &sc_owner_page );
    break;
  case 5: //デバッグ入力
    wk->p_pageData  = Page_PushPage( wk->p_pageData, &sc_debug_flag_page );
    break;
  default:
    GF_ASSERT(0);
  }
  wk->modify_type = DATA_MODIRY_TYPE_CHANGE;
  Page_StoreData( wk, wk->p_resort_sv );
  wk->Seq = SEQ_REDRAW;
}

//普通に受け取るだけのテーブル
static const struct
{
  EDITBOX_ID editBoxID;
  RESORT_CITY_DATA_PARAM resort_param;
} sc_city_restore_tbl[]  =
{
  { EDITBOX_ID_CITY_LV,      RESORT_CITY_DATA_PARAM_LV            },
  { EDITBOX_ID_CITY_EXP,     RESORT_CITY_DATA_PARAM_EXP           },
  { EDITBOX_ID_CITY_TEX,     RESORT_CITY_DATA_PARAM_TEX           },
  { EDITBOX_ID_CITY_FUN_DAY,  RESORT_CITY_DATA_FUN_DAY_FLAG         },
  { EDITBOX_ID_IS_CELEB_APPEAL,RESORT_CITY_DATA_CELEB_DAY_FLAG },
  { EDITBOX_ID_IS_CELEB_TRADE, RESORT_CITY_DATA_CELEB_TRADE_FLAG },
  { EDITBOX_ID_IS_TUTORIAL,   RESORT_CITY_DATA_PARAM_IS_TUTORIAL  },
  { EDITBOX_ID_IS_EV_PRIZE1,  RESORT_CITY_DATA_PARAM_EV_PRIZE_SEC03 },
  { EDITBOX_ID_IS_EV_PRIZE2,  RESORT_CITY_DATA_PARAM_EV_PRIZE_SEC04 },
  { EDITBOX_ID_IS_EV_PRIZE3,  RESORT_CITY_DATA_PARAM_EV_PRIZE_CITYNAME },
  { EDITBOX_ID_IS_EV_PRIZE4,  RESORT_CITY_DATA_PARAM_EV_PRIZE_NEON },
  { EDITBOX_ID_IS_EV_PRIZE5,  RESORT_CITY_DATA_PARAM_EV_PRIZE_SCOUT },
  { EDITBOX_ID_IS_EV_PRIZE6,  RESORT_CITY_DATA_PARAM_EV_PRIZE_DENDOU },
  { EDITBOX_ID_IS_PRIZE1,     RESORT_CITY_DATA_PARAM_PRIZE_SEC03 },
  { EDITBOX_ID_IS_PRIZE2,     RESORT_CITY_DATA_PARAM_PRIZE_SEC04 },
  { EDITBOX_ID_IS_PRIZE3,     RESORT_CITY_DATA_PARAM_PRIZE_CITYNAME },
  { EDITBOX_ID_IS_PRIZE4,     RESORT_CITY_DATA_PARAM_PRIZE_NEON },
  { EDITBOX_ID_IS_PRIZE5,     RESORT_CITY_DATA_PARAM_PRIZE_SCOUT },
  { EDITBOX_ID_IS_PRIZE6,     RESORT_CITY_DATA_PARAM_PRIZE_DENDOU },


};
static void City_StoreData( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv )
{
  int i;
  RESORT_CITY_DATA *p_city = RESONANCE_RESORT_SV_GetCityData( p_resort_sv );

  //普通に受け取るだけのデータ
  for( i = 0; i < NELEMS(sc_city_restore_tbl); i++ )
  {
    p_wk->BoxValue[sc_city_restore_tbl[i].editBoxID]  = RESORT_CITY_DATA_GetData( p_city, sc_city_restore_tbl[i].resort_param, NULL );
  }

  //文字データ
  {
    STRCODE strcode[64];

    RESORT_CITY_DATA_GetData( p_city, RESORT_CITY_DATA_PARAM_CITY_NAME, strcode );
    GFL_STR_SetStringCode( p_wk->BoxStrBuf[ EDITBOX_ID_CITY_CITYNAME - EDITBOX_ID_MAX ], strcode );

    RESORT_CITY_DATA_GetData( p_city, RESORT_CITY_DATA_PARAM_AUTHER_NAME, strcode );
    GFL_STR_SetStringCode( p_wk->BoxStrBuf[ EDITBOX_ID_CITY_AUTHERNAME - EDITBOX_ID_MAX ], strcode );
  }
}
static BOOL City_ReStoreData( RESONANCE_RESORT_SV *p_resort_sv, const DEBUG_INPUT_WORK *cp_wk )
{
  int i;
  RESORT_CITY_DATA *p_city = RESONANCE_RESORT_SV_GetCityData( p_resort_sv );

  //普通に受け取るだけのデータ
  for( i = 0; i < NELEMS(sc_city_restore_tbl); i++ )
  {
    RESORT_CITY_DATA_SetData( p_city, sc_city_restore_tbl[i].resort_param, cp_wk->BoxValue[sc_city_restore_tbl[i].editBoxID] );
  }

  //文字データ
  {
    const STRCODE *cp_strcode;


    cp_strcode = GFL_STR_GetStringCodePointer( cp_wk->BoxStrBuf[ EDITBOX_ID_CITY_CITYNAME - EDITBOX_ID_MAX ] );
    RESORT_CITY_DATA_SetData( p_city, RESORT_CITY_DATA_PARAM_CITY_NAME, (u32)cp_strcode );

    cp_strcode = GFL_STR_GetStringCodePointer( cp_wk->BoxStrBuf[ EDITBOX_ID_CITY_AUTHERNAME - EDITBOX_ID_MAX ] );
    RESORT_CITY_DATA_SetData( p_city, RESORT_CITY_DATA_PARAM_AUTHER_NAME, (u32)cp_strcode );
  }

  return TRUE;
}
//=============================================================================
/**
 *  住民データのセット関数
 */
//=============================================================================
//普通に受け取るだけのテーブル
static const struct
{
  EDITBOX_ID editBoxID;
  RESORT_DATA_PARAM resort_param;
} sc_resident_restore_tbl[]  =
{
  { EDITBOX_ID_BASIC_TRAINERID, RESORT_DATA_PARAM_TRAINER_ID },
  { EDITBOX_ID_BASIC_CONTRY,    RESORT_DATA_PARAM_NATION },
  { EDITBOX_ID_BASIC_AREA,      RESORT_DATA_PARAM_AREA },
  { EDITBOX_ID_BASIC_LANG,      RESORT_DATA_PARAM_LANG },
  { EDITBOX_ID_BASIC_VER,       RESORT_DATA_PARAM_VER },
  { EDITBOX_ID_BASIC_VIEW,      RESORT_DATA_PARAM_OBJCODE },
  { EDITBOX_ID_BASIC_SEX,       RESORT_DATA_PARAM_SEX },
  { EDITBOX_ID_BASIC_PLAY_HOUR, RESORT_DATA_PARAM_PLAY_HOUR },
  { EDITBOX_ID_BASIC_PLAY_MIN,  RESORT_DATA_PARAM_PLAY_MIN },
  { EDITBOX_ID_SUB_SPECIAL,     RESORT_DATA_PARAM_SPECIAL },
  { EDITBOX_ID_SUB_WANTJOB,     RESORT_DATA_PARAM_WANT_JOB },
  { EDITBOX_ID_SUB_CITYLV,      RESORT_DATA_PARAM_CITYLV },
  { EDITBOX_ID_RESI_PRESENT_ID,   RESORT_DATA_PARAM_PRESENT_BIT  },
  { EDITBOX_ID_RESI_MEET_YEAR,    RESORT_DATA_PARAM_MEET_YEAR   },
  { EDITBOX_ID_RESI_MEET_MONTH,   RESORT_DATA_PARAM_MEET_MONTH  },
  { EDITBOX_ID_RESI_MEET_DAY,     RESORT_DATA_PARAM_MEET_DAY    },
  { EDITBOX_ID_RESI_MEET_HOUR,    RESORT_DATA_PARAM_MEET_HOUR   },
  { EDITBOX_ID_RESI_MEET_MIN,     RESORT_DATA_PARAM_MEET_MIN    },
  { EDITBOX_ID_RESI_COMM_ID,      RESORT_DATA_PARAM_COMM_ID     },
  { EDITBOX_ID_RESI_MERGE,        RESORT_DATA_PARAM_UPDATE },
  { EDITBOX_ID_RESI_KEEP,         RESORT_DATA_PARAM_KEEP },
  { EDITBOX_ID_RESI_EXTEND_BIT,  RESORT_DATA_PARAM_EXTEND_BIT },
  { EDITBOX_ID_RESI_PEOPLE_ID,  RESORT_DATA_PARAM_PEOPLE_ID },
  { EDITBOX_ID_RESI_PLACE_ID,   RESORT_DATA_PARAM_PLACE_ID },
  { EDITBOX_ID_RESI_KOSEI,      RESORT_DATA_PARAM_KOSEI },
  { EDITBOX_ID_RESI_TYPE,   RESORT_DATA_PARAM_TYPE },
  { EDITBOX_ID_RESI_UPDATE,   RESORT_DATA_PARAM_UPDATE },
  { EDITBOX_ID_EXT1_MEDAL_ID,      RESORT_DATA_PARAM_EXT1_RECOMMEND_MEDAL_ID },
  { EDITBOX_ID_EXT1_MEDAL_NUM,     RESORT_DATA_PARAM_EXT1_MEDAL_NUM },
  { EDITBOX_ID_EXT2_RANK_00,  RESORT_DATA_PARAM_EXT2_RANK_00, },
  { EDITBOX_ID_EXT2_RANK_01,  RESORT_DATA_PARAM_EXT2_RANK_01, },
  { EDITBOX_ID_EXT2_RANK_02,  RESORT_DATA_PARAM_EXT2_RANK_02, },
  { EDITBOX_ID_EXT2_RANK_03,  RESORT_DATA_PARAM_EXT2_RANK_03, },
  { EDITBOX_ID_EXT3_RANK_04,  RESORT_DATA_PARAM_EXT3_RANK_04, },
  { EDITBOX_ID_EXT3_RANK_05,  RESORT_DATA_PARAM_EXT3_RANK_05, },
  { EDITBOX_ID_EXT3_RANK_06,  RESORT_DATA_PARAM_EXT3_RANK_06, },
  { EDITBOX_ID_EXT3_RANK_07,  RESORT_DATA_PARAM_EXT3_RANK_07, },
  { EDITBOX_ID_EXT4_GOSSIP_00,  RESORT_DATA_PARAM_EXT4_GOSSIP_00 },
  { EDITBOX_ID_EXT4_GOSSIP_01,  RESORT_DATA_PARAM_EXT4_GOSSIP_01 },
  { EDITBOX_ID_EXT4_GOSSIP_02,  RESORT_DATA_PARAM_EXT4_GOSSIP_02 },
  { EDITBOX_ID_EXT4_GOSSIP_03,  RESORT_DATA_PARAM_EXT4_GOSSIP_03 },
  { EDITBOX_ID_EXT4_GOSSIP_04,  RESORT_DATA_PARAM_EXT4_GOSSIP_04 },
  { EDITBOX_ID_EXT4_GOSSIP_05,  RESORT_DATA_PARAM_EXT4_GOSSIP_05 },
  { EDITBOX_ID_EXT4_GOSSIP_06,  RESORT_DATA_PARAM_EXT4_GOSSIP_06 },
  { EDITBOX_ID_EXT4_GOSSIP_07,  RESORT_DATA_PARAM_EXT4_GOSSIP_07 },
  { EDITBOX_ID_EXT4_GOSSIP_08,  RESORT_DATA_PARAM_EXT4_GOSSIP_08 },
  { EDITBOX_ID_EXT4_GOSSIP_09,  RESORT_DATA_PARAM_EXT4_GOSSIP_09 },
  { EDITBOX_ID_EXT4_GOSSIP_10,  RESORT_DATA_PARAM_EXT4_GOSSIP_10 },
  { EDITBOX_ID_EXT4_GOSSIP_11,  RESORT_DATA_PARAM_EXT4_GOSSIP_11 },
  { EDITBOX_ID_EXT4_GOSSIP_12,  RESORT_DATA_PARAM_EXT4_GOSSIP_12 },
  { EDITBOX_ID_EXT4_GOSSIP_13,  RESORT_DATA_PARAM_EXT4_GOSSIP_13 },
  { EDITBOX_ID_EXT4_GOSSIP_14,  RESORT_DATA_PARAM_EXT4_GOSSIP_14 },
  { EDITBOX_ID_EXT4_GOSSIP_15,  RESORT_DATA_PARAM_EXT4_GOSSIP_15 },
  { EDITBOX_ID_EXT8_RECORD_00,  RESORT_DATA_PARAM_EXT5_RECORD_00 },
  { EDITBOX_ID_EXT8_RECORD_01,  RESORT_DATA_PARAM_EXT5_RECORD_01 },
  { EDITBOX_ID_EXT8_RECORD_02,  RESORT_DATA_PARAM_EXT5_RECORD_02 },
  { EDITBOX_ID_EXT8_RECORD_03,  RESORT_DATA_PARAM_EXT5_RECORD_03 },
};
static void Resident_StoreData( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv )
{
  //もしAddだったら何もしない
  if( p_wk->modify_type == DATA_MODIRY_TYPE_ADD )
  {
    GFL_STR_ClearBuffer(p_wk->BoxStrBuf[ EDITBOX_ID_BASIC_NAME - EDITBOX_ID_MAX ]);
    GFL_STR_ClearBuffer(p_wk->BoxStrBuf[ EDITBOX_ID_BASIC_INTRODUCTION - EDITBOX_ID_MAX ]);
    GFL_STR_ClearBuffer(p_wk->BoxStrBuf[ EDITBOX_ID_EXT6_PHRASE - EDITBOX_ID_MAX ]);
  }
  else
  {
    RESORT_PEOPLE_ALL_DATA *p_people_all = RESONANCE_RESORT_SV_GetPeopleAllData( p_resort_sv );
    int index = p_wk->BoxValue[EDITBOX_ID_FIRST_CHANGE_NUM];
    RESORT_RESIDENT_DATA * p_data = RESORT_PEOPLE_ALL_DATA_GetResident( p_people_all, index );
    STRCODE strcode[64];
    int i;

    if( index >= RESORT_RESIDENT_DATA_NUM )
    {
      return;
    }

    //普通に受け取るだけのデータ
    for( i = 0; i < NELEMS(sc_resident_restore_tbl); i++ )
    {
      p_wk->BoxValue[sc_resident_restore_tbl[i].editBoxID]  = RESORT_RESIDENT_DATA_GetData( p_data, sc_resident_restore_tbl[i].resort_param, NULL );
    }

    //文字データ
    RESORT_RESIDENT_DATA_GetData( p_data, RESORT_DATA_PARAM_NAME, strcode );
    GFL_STR_SetStringCode( p_wk->BoxStrBuf[ EDITBOX_ID_BASIC_NAME - EDITBOX_ID_MAX ], strcode );
    RESORT_RESIDENT_DATA_GetData( p_data, RESORT_DATA_PARAM_INTRODUCTION, strcode );
    GFL_STR_SetStringCode( p_wk->BoxStrBuf[ EDITBOX_ID_BASIC_INTRODUCTION - EDITBOX_ID_MAX ], strcode );
    RESORT_RESIDENT_DATA_GetData( p_data, RESORT_DATA_PARAM_EXT6_PHRASE, strcode );
    GFL_STR_SetStringCode( p_wk->BoxStrBuf[ EDITBOX_ID_EXT6_PHRASE - EDITBOX_ID_MAX ], strcode );


    //施設データ
    {
      RESORT_INSTITUTION_DATA *p_institution = RESORT_RESIDENT_DATA_GetInstitution( p_data );
      p_wk->BoxValue[EDITBOX_ID_RESI_INSTITUTION_ID]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_ID );
      p_wk->BoxValue[EDITBOX_ID_RESI_LV]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_LV );
      p_wk->BoxValue[EDITBOX_ID_RESI_EXP]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_EXP );
      p_wk->BoxValue[EDITBOX_ID_RESI_EV_WK_00]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_WORK_00 );
      p_wk->BoxValue[EDITBOX_ID_RESI_EV_WK_01]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_WORK_01 );
      p_wk->BoxValue[EDITBOX_ID_RESI_EV_BIT]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_BIT );
    }


    //日付
    {
      RESORT_DATE date = RESORT_RESIDENT_DATA_GetData( p_data, RESORT_DATA_PARAM_EXT1_RECOMMEND_DATE, NULL );
      p_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_YEAR]  = RESORT_DATE_GET_YEAR( date );
      p_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_MONTH]  = RESORT_DATE_GET_MONTH( date );
      p_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_DAY]  = RESORT_DATE_GET_DAY( date );

      for( i = 0; i < 4; i++ )
      {
        date = RESORT_RESIDENT_DATA_GetData( p_data, RESORT_DATA_PARAM_EXT5_RECORD_DATE_00+i, NULL );
        p_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_YEAR_00+i] = RESORT_DATE_GET_YEAR( date );
        p_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_MONTH_00+i] = RESORT_DATE_GET_MONTH( date );
        p_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_DAY_00+i] = RESORT_DATE_GET_DAY( date );
      }
    }
  }

}

static BOOL Resident_ReStoreData( RESONANCE_RESORT_SV *p_resort_sv, const DEBUG_INPUT_WORK *cp_wk )
{
  RESORT_PEOPLE_ALL_DATA *p_people_all = RESONANCE_RESORT_SV_GetPeopleAllData( p_resort_sv );
  RESORT_RESIDENT_DATA * p_data = NULL;
  const STRCODE *cp_strcode;
  int i;

  if( cp_wk->modify_type == DATA_MODIRY_TYPE_ADD )
  {
    int i;
    BOOL is_exits = FALSE;
    for( i = 0; i < RESORT_RESIDENT_DATA_NUM; i++ )
    {
      p_data = RESORT_PEOPLE_ALL_DATA_GetResident( p_people_all, i);
      if( RESORT_RESIDENT_DATA_IsEmpty( p_data ) )
      {
        is_exits = TRUE;
        break;
      }
    }
    if( is_exits == FALSE )
    {
      //いれられなかった
      return FALSE;
    }
  }
  else
  {
    int index = cp_wk->BoxValue[EDITBOX_ID_FIRST_CHANGE_NUM];
    if( index >= RESORT_RESIDENT_DATA_NUM )
    {
      return FALSE;
    }
    p_data = RESORT_PEOPLE_ALL_DATA_GetResident( p_people_all, index );
  }

  //普通に受け取るだけのデータ
  for( i = 0; i < NELEMS(sc_resident_restore_tbl); i++ )
  {
    RESORT_RESIDENT_DATA_SetData( p_data, sc_resident_restore_tbl[i].resort_param, cp_wk->BoxValue[sc_resident_restore_tbl[i].editBoxID] );
  }
  //文字データ
  cp_strcode = GFL_STR_GetStringCodePointer( cp_wk->BoxStrBuf[ EDITBOX_ID_BASIC_NAME - EDITBOX_ID_MAX ] );
  RESORT_RESIDENT_DATA_SetData( p_data, RESORT_DATA_PARAM_NAME, (u32)cp_strcode );
  cp_strcode = GFL_STR_GetStringCodePointer( cp_wk->BoxStrBuf[ EDITBOX_ID_BASIC_INTRODUCTION - EDITBOX_ID_MAX ] );
  RESORT_RESIDENT_DATA_SetData( p_data, RESORT_DATA_PARAM_INTRODUCTION, (u32)cp_strcode );
  cp_strcode = GFL_STR_GetStringCodePointer( cp_wk->BoxStrBuf[ EDITBOX_ID_EXT6_PHRASE - EDITBOX_ID_MAX ] );
  RESORT_RESIDENT_DATA_SetData( p_data, RESORT_DATA_PARAM_EXT6_PHRASE, (u32)cp_strcode );

  //施設データ
  {
    RESORT_INSTITUTION_DATA *p_institution = RESORT_RESIDENT_DATA_GetInstitution( p_data );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_ID, cp_wk->BoxValue[EDITBOX_ID_RESI_INSTITUTION_ID] );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_LV, cp_wk->BoxValue[EDITBOX_ID_RESI_LV] );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_EXP, cp_wk->BoxValue[EDITBOX_ID_RESI_EXP] );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_WORK_00, cp_wk->BoxValue[EDITBOX_ID_RESI_EV_WK_00] );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_WORK_01, cp_wk->BoxValue[EDITBOX_ID_RESI_EV_WK_01] );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_BIT, cp_wk->BoxValue[EDITBOX_ID_RESI_EV_BIT] );
  }

  //日付
  {
    RESORT_DATE date;

    date = RESORT_DATE_SET( cp_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_YEAR], 
                            cp_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_MONTH],
                            cp_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_DAY] );
    RESORT_RESIDENT_DATA_SetData( p_data, RESORT_DATA_PARAM_EXT1_RECOMMEND_DATE, date );


    for( i = 0; i < 4; i++ )
    {
      date = RESORT_DATE_SET( cp_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_YEAR_00+i],
                              cp_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_MONTH_00+i],
                              cp_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_DAY_00+i] );
      RESORT_RESIDENT_DATA_SetData( p_data, RESORT_DATA_PARAM_EXT5_RECORD_DATE_00+i, date );
    }
  }

  return TRUE;
}

static void Tourist_StoreData( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv )
{
  //もしAddだったら何もしない
  if( p_wk->modify_type == DATA_MODIRY_TYPE_ADD )
  {
    GFL_STR_ClearBuffer(p_wk->BoxStrBuf[ EDITBOX_ID_BASIC_NAME - EDITBOX_ID_MAX ]);
    GFL_STR_ClearBuffer(p_wk->BoxStrBuf[ EDITBOX_ID_BASIC_INTRODUCTION - EDITBOX_ID_MAX ]);
    GFL_STR_ClearBuffer(p_wk->BoxStrBuf[ EDITBOX_ID_EXT6_PHRASE - EDITBOX_ID_MAX ]);
  }
  else
  {
    RESORT_RECV_BUFF *p_buff = RESONANCE_RESORT_SV_GetDataBuff( p_resort_sv );
    int index = p_wk->BoxValue[EDITBOX_ID_FIRST_CHANGE_NUM];
    RESORT_RECV_DATA * p_data = RESORT_RECV_BUFF_GetData( p_buff, index );
    STRCODE strcode[64];
    int i;

    if( index >= RESONANCE_RESORT_SV_RECV_BUFF_NUM )
    {
      return;
    }

    //普通に受け取るだけのデータ
    for( i = 0; i < NELEMS(sc_resident_restore_tbl); i++ )
    {
      p_wk->BoxValue[sc_resident_restore_tbl[i].editBoxID]  = RESORT_RECV_DATA_GetData( p_data, sc_resident_restore_tbl[i].resort_param, NULL );
    }

    //文字データ
    RESORT_RECV_DATA_GetData( p_data, RESORT_DATA_PARAM_NAME, strcode );
    GFL_STR_SetStringCode( p_wk->BoxStrBuf[ EDITBOX_ID_BASIC_NAME - EDITBOX_ID_MAX ], strcode );
    RESORT_RECV_DATA_GetData( p_data, RESORT_DATA_PARAM_INTRODUCTION, strcode );
    GFL_STR_SetStringCode( p_wk->BoxStrBuf[ EDITBOX_ID_BASIC_INTRODUCTION - EDITBOX_ID_MAX ], strcode );
    RESORT_RECV_DATA_GetData( p_data, RESORT_DATA_PARAM_EXT6_PHRASE, strcode );
    GFL_STR_SetStringCode( p_wk->BoxStrBuf[ EDITBOX_ID_EXT6_PHRASE - EDITBOX_ID_MAX ], strcode );

    //施設データ
    {
      RESORT_INSTITUTION_DATA *p_institution = RESORT_RESIDENT_DATA_GetInstitution( p_data );
      p_wk->BoxValue[EDITBOX_ID_RESI_INSTITUTION_ID]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_ID );
      p_wk->BoxValue[EDITBOX_ID_RESI_LV]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_LV );
      p_wk->BoxValue[EDITBOX_ID_RESI_EXP]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_EXP );
      p_wk->BoxValue[EDITBOX_ID_RESI_EV_WK_00]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_WORK_00 );
      p_wk->BoxValue[EDITBOX_ID_RESI_EV_WK_01]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_WORK_01 );
      p_wk->BoxValue[EDITBOX_ID_RESI_EV_BIT]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_BIT );
    }


    //日付
    {
      RESORT_DATE date = RESORT_RECV_DATA_GetData( p_data, RESORT_DATA_PARAM_EXT1_RECOMMEND_DATE, NULL );
      p_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_YEAR]  = RESORT_DATE_GET_YEAR( date );
      p_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_MONTH]  = RESORT_DATE_GET_MONTH( date );
      p_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_DAY]  = RESORT_DATE_GET_DAY( date );

      for( i = 0; i < 4; i++ )
      {
        date = RESORT_RECV_DATA_GetData( p_data, RESORT_DATA_PARAM_EXT5_RECORD_DATE_00+i, NULL );
        p_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_YEAR_00+i] = RESORT_DATE_GET_YEAR( date );
        p_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_MONTH_00+i] = RESORT_DATE_GET_MONTH( date );
        p_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_DAY_00+i] = RESORT_DATE_GET_DAY( date );
      }
    }
  }

}

static BOOL Tourist_ReStoreData( RESONANCE_RESORT_SV *p_resort_sv, const DEBUG_INPUT_WORK *cp_wk )
{
  RESORT_RECV_BUFF *p_buff = RESONANCE_RESORT_SV_GetDataBuff( p_resort_sv );
  RESORT_RECV_DATA * p_data = NULL;
  const STRCODE *cp_strcode;
  int i;

  if( cp_wk->modify_type == DATA_MODIRY_TYPE_ADD )
  {
    int i;
    BOOL is_exits = FALSE;
    for( i = 0; i < RESONANCE_RESORT_SV_RECV_BUFF_NUM; i++ )
    {

      p_data = RESORT_RECV_BUFF_GetData( p_buff, i );
      if( RESORT_RECV_DATA_IsEmpty( p_data ) )
      {
        is_exits = TRUE;
        break;
      }
    }
    if( is_exits == FALSE )
    {
      //いれられなかった
      return FALSE;
    }
  }
  else
  {
    int index = cp_wk->BoxValue[EDITBOX_ID_FIRST_CHANGE_NUM];
    if( index >= RESONANCE_RESORT_SV_RECV_BUFF_NUM )
    {
      return FALSE;
    }
    p_data = RESORT_RECV_BUFF_GetData( p_buff, index );
  }

  //普通に受け取るだけのデータ
  for( i = 0; i < NELEMS(sc_resident_restore_tbl); i++ )
  {
    RESORT_RECV_DATA_SetData( p_data, sc_resident_restore_tbl[i].resort_param, cp_wk->BoxValue[sc_resident_restore_tbl[i].editBoxID] );
  }
  //文字データ
  cp_strcode = GFL_STR_GetStringCodePointer( cp_wk->BoxStrBuf[ EDITBOX_ID_BASIC_NAME - EDITBOX_ID_MAX ] );
  RESORT_RECV_DATA_SetData( p_data, RESORT_DATA_PARAM_NAME, (u32)cp_strcode );
  cp_strcode = GFL_STR_GetStringCodePointer( cp_wk->BoxStrBuf[ EDITBOX_ID_BASIC_INTRODUCTION - EDITBOX_ID_MAX ] );
  RESORT_RECV_DATA_SetData( p_data, RESORT_DATA_PARAM_INTRODUCTION, (u32)cp_strcode );
  cp_strcode = GFL_STR_GetStringCodePointer( cp_wk->BoxStrBuf[ EDITBOX_ID_EXT6_PHRASE - EDITBOX_ID_MAX ] );
  RESORT_RECV_DATA_SetData( p_data, RESORT_DATA_PARAM_EXT6_PHRASE, (u32)cp_strcode );

  //施設データ
  {
    RESORT_INSTITUTION_DATA *p_institution = RESORT_RESIDENT_DATA_GetInstitution( p_data );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_ID, cp_wk->BoxValue[EDITBOX_ID_RESI_INSTITUTION_ID] );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_LV, cp_wk->BoxValue[EDITBOX_ID_RESI_LV] );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_EXP, cp_wk->BoxValue[EDITBOX_ID_RESI_EXP] );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_WORK_00, cp_wk->BoxValue[EDITBOX_ID_RESI_EV_WK_00] );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_WORK_01, cp_wk->BoxValue[EDITBOX_ID_RESI_EV_WK_01] );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_BIT, cp_wk->BoxValue[EDITBOX_ID_RESI_EV_BIT] );
  }

  //日付
  {
    RESORT_DATE date;

    date = RESORT_DATE_SET( cp_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_YEAR], 
                            cp_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_MONTH],
                            cp_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_DAY] );
    RESORT_RECV_DATA_SetData( p_data, RESORT_DATA_PARAM_EXT1_RECOMMEND_DATE, date );


    for( i = 0; i < 4; i++ )
    {
      date = RESORT_DATE_SET( cp_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_YEAR_00+i],
                              cp_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_MONTH_00+i],
                              cp_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_DAY_00+i] );
      RESORT_RECV_DATA_SetData( p_data, RESORT_DATA_PARAM_EXT5_RECORD_DATE_00+i, date );
    }
  }

  //更新フラグ
  RESORT_RECV_DATA_SetData(p_data,RESORT_DATA_PARAM_UPDATE, RESORT_RECV_DATA_UPDATE_FIRST );

  return TRUE;
}


static void Owner_StoreData( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv )
{
  {
    RESORT_PEOPLE_ALL_DATA *p_people_all = RESONANCE_RESORT_SV_GetPeopleAllData( p_resort_sv );
    RESORT_RECV_DATA * p_data = RESORT_PEOPLE_ALL_DATA_GetOwnerData( p_people_all );
    STRCODE strcode[64];
    int i;

    //普通に受け取るだけのデータ
    for( i = 0; i < NELEMS(sc_resident_restore_tbl); i++ )
    {
      p_wk->BoxValue[sc_resident_restore_tbl[i].editBoxID]  = RESORT_RECV_DATA_GetData( p_data, sc_resident_restore_tbl[i].resort_param, NULL );
    }

    //文字データ
    RESORT_RECV_DATA_GetData( p_data, RESORT_DATA_PARAM_NAME, strcode );
    GFL_STR_SetStringCode( p_wk->BoxStrBuf[ EDITBOX_ID_BASIC_NAME - EDITBOX_ID_MAX ], strcode );
    RESORT_RECV_DATA_GetData( p_data, RESORT_DATA_PARAM_INTRODUCTION, strcode );
    GFL_STR_SetStringCode( p_wk->BoxStrBuf[ EDITBOX_ID_BASIC_INTRODUCTION - EDITBOX_ID_MAX ], strcode );
    RESORT_RECV_DATA_GetData( p_data, RESORT_DATA_PARAM_EXT6_PHRASE, strcode );
    GFL_STR_SetStringCode( p_wk->BoxStrBuf[ EDITBOX_ID_EXT6_PHRASE - EDITBOX_ID_MAX ], strcode );


    //施設データ
    {
      RESORT_INSTITUTION_DATA *p_institution = RESORT_RESIDENT_DATA_GetInstitution( p_data );
      p_wk->BoxValue[EDITBOX_ID_RESI_INSTITUTION_ID]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_ID );
      p_wk->BoxValue[EDITBOX_ID_RESI_LV]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_LV );
      p_wk->BoxValue[EDITBOX_ID_RESI_EXP]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_EXP );
      p_wk->BoxValue[EDITBOX_ID_RESI_EV_WK_00]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_WORK_00 );
      p_wk->BoxValue[EDITBOX_ID_RESI_EV_WK_01]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_WORK_01 );
      p_wk->BoxValue[EDITBOX_ID_RESI_EV_BIT]  = RESORT_INSTITUTION_DATA_GetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_BIT );
    }


    //日付
    {
      RESORT_DATE date = RESORT_RECV_DATA_GetData( p_data, RESORT_DATA_PARAM_EXT1_RECOMMEND_DATE, NULL );
      p_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_YEAR]  = RESORT_DATE_GET_YEAR( date );
      p_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_MONTH]  = RESORT_DATE_GET_MONTH( date );
      p_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_DAY]  = RESORT_DATE_GET_DAY( date );

      for( i = 0; i < 4; i++ )
      {
        date = RESORT_RECV_DATA_GetData( p_data, RESORT_DATA_PARAM_EXT5_RECORD_DATE_00+i, NULL );
        p_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_YEAR_00+i] = RESORT_DATE_GET_YEAR( date );
        p_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_MONTH_00+i] = RESORT_DATE_GET_MONTH( date );
        p_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_DAY_00+i] = RESORT_DATE_GET_DAY( date );
      }
    }
  }
}

static BOOL Owner_ReStoreData( RESONANCE_RESORT_SV *p_resort_sv, const DEBUG_INPUT_WORK *cp_wk )
{
  RESORT_PEOPLE_ALL_DATA *p_people_all = RESONANCE_RESORT_SV_GetPeopleAllData( p_resort_sv );
  RESORT_RECV_DATA * p_data = RESORT_PEOPLE_ALL_DATA_GetOwnerData( p_people_all );
  const STRCODE *cp_strcode;
  int i;

  //普通に受け取るだけのデータ
  for( i = 0; i < NELEMS(sc_resident_restore_tbl); i++ )
  {
    RESORT_RECV_DATA_SetData( p_data, sc_resident_restore_tbl[i].resort_param, cp_wk->BoxValue[sc_resident_restore_tbl[i].editBoxID] );
  }
  //文字データ
  cp_strcode = GFL_STR_GetStringCodePointer( cp_wk->BoxStrBuf[ EDITBOX_ID_BASIC_NAME - EDITBOX_ID_MAX ] );
  RESORT_RECV_DATA_SetData( p_data, RESORT_DATA_PARAM_NAME, (u32)cp_strcode );
  cp_strcode = GFL_STR_GetStringCodePointer( cp_wk->BoxStrBuf[ EDITBOX_ID_BASIC_INTRODUCTION - EDITBOX_ID_MAX ] );
  RESORT_RECV_DATA_SetData( p_data, RESORT_DATA_PARAM_INTRODUCTION, (u32)cp_strcode );
  cp_strcode = GFL_STR_GetStringCodePointer( cp_wk->BoxStrBuf[ EDITBOX_ID_EXT6_PHRASE - EDITBOX_ID_MAX ] );
  RESORT_RECV_DATA_SetData( p_data, RESORT_DATA_PARAM_EXT6_PHRASE, (u32)cp_strcode );


  //施設データ
  {
    RESORT_INSTITUTION_DATA *p_institution = RESORT_RESIDENT_DATA_GetInstitution( p_data );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_ID, cp_wk->BoxValue[EDITBOX_ID_RESI_INSTITUTION_ID] );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_EXP, cp_wk->BoxValue[EDITBOX_ID_RESI_EXP] );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_WORK_00, cp_wk->BoxValue[EDITBOX_ID_RESI_EV_WK_00] );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_WORK_01, cp_wk->BoxValue[EDITBOX_ID_RESI_EV_WK_01] );
    RESORT_INSTITUTION_DATA_SetData( p_institution, RESORT_INSTITUTION_DATA_PARAM_BIT, cp_wk->BoxValue[EDITBOX_ID_RESI_EV_BIT] );
  }


  //日付
  {
    RESORT_DATE date;

    date = RESORT_DATE_SET( cp_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_YEAR], 
                            cp_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_MONTH],
                            cp_wk->BoxValue[EDITBOX_ID_EXT1_MEDAL_DAY] );
    RESORT_RECV_DATA_SetData( p_data, RESORT_DATA_PARAM_EXT1_RECOMMEND_DATE, date );


    for( i = 0; i < 4; i++ )
    {
      date = RESORT_DATE_SET( cp_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_YEAR_00+i],
                              cp_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_MONTH_00+i],
                              cp_wk->BoxValue[ EDITBOX_ID_EXT8_RECORD_DAY_00+i] );
      RESORT_RECV_DATA_SetData( p_data, RESORT_DATA_PARAM_EXT5_RECORD_DATE_00+i, date );
    }
  }

  //更新フラグ
  RESORT_RECV_DATA_SetData(p_data,RESORT_DATA_PARAM_UPDATE, RESORT_RECV_DATA_UPDATE_FIRST );

  return TRUE;

}

//普通に受け取るだけのテーブル
static const struct
{
  EDITBOX_ID editBoxID;
  RESORT_DATA_PARAM resort_param;
} sc_shoppos_restore_tbl[]  =
{
  { EDITBOX_ID_SHOP_ID_00,    RESORT_INSTITUTION_DATA_PARAM_ID },
  { EDITBOX_ID_SHOP_LV_00,    RESORT_INSTITUTION_DATA_PARAM_LV },
  { EDITBOX_ID_SHOP_EXP_00,   RESORT_INSTITUTION_DATA_PARAM_EXP },
};

#define SHOPPOS_OFS (EDITBOX_ID_SHOP_TYPE_00-EDITBOX_ID_SHOP_ID_00+1)

static void ShopPos_StoreData( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv )
{

  RESORT_PEOPLE_ALL_DATA *p_all_people = RESONANCE_RESORT_SV_GetPeopleAllData( p_resort_sv );
  int i, j;

  //まずは住人をいっぱいにする
  {
  RESORT_BINARY_SHOP *p_shop =  RESORT_BINARY_SHOP_Init( GFL_HEAP_LOWID(p_wk->HeapID) );
    RESORT_RECV_DATA *p_recv = RESORT_RECV_DATA_Init( GFL_HEAP_LOWID(p_wk->HeapID) );
    for( i = 0; i < RESORT_RESIDENT_DATA_NUM; i++ )
    {
      RESORT_RESIDENT_DATA *p_dst = RESORT_PEOPLE_ALL_DATA_GetResident( p_all_people, i );
      if( RESORT_RESIDENT_DATA_IsEmpty( p_dst ) )
      {
        Debug_Resort_SetRecv( p_recv, p_wk->p_gamedata );
        RESORT_RESIDENT_DATA_ConvertRecv( p_dst, p_recv, p_shop, 63-i, RESORT_PLACEID_FIELD );
      }
    }

    RESORT_RECV_DATA_Exit( p_recv );
    RESORT_BINARY_SHOP_Exit(p_shop);
  }

  for( i = 0; i < RESORT_RESIDENT_DATA_NUM; i++ )
  {
    RESORT_RESIDENT_DATA *p_data = RESORT_PEOPLE_ALL_DATA_GetResident( p_all_people, i );
    RESORT_INSTITUTION_DATA *p_ins = RESORT_RESIDENT_DATA_GetInstitution(p_data);
    const RESORT_BINARY_SHOP_DATA *cp_shop_data = RESORT_BINARY_SHOP_SearchDataByData( p_wk->p_shop, p_data );
    for( j = 0; j < NELEMS(sc_shoppos_restore_tbl); j++ )
    {
      p_wk->BoxValue[sc_shoppos_restore_tbl[j].editBoxID+SHOPPOS_OFS*i] = 
        RESORT_INSTITUTION_DATA_GetData( p_ins, sc_shoppos_restore_tbl[j].resort_param );
    }
    p_wk->BoxValue[EDITBOX_ID_SHOP_KIND_00+SHOPPOS_OFS*i] = RESORT_BINARY_SHOP_DATA_GetData(cp_shop_data, RESORT_BINARY_SHOP_PARAM_SHOP );
    p_wk->BoxValue[EDITBOX_ID_SHOP_TYPE_00+SHOPPOS_OFS*i] = RESORT_BINARY_SHOP_DATA_GetData(cp_shop_data, RESORT_BINARY_SHOP_PARAM_TYPE );
  }
}

static BOOL ShopPos_ReStoreData( RESONANCE_RESORT_SV *p_resort_sv, const DEBUG_INPUT_WORK *cp_wk )
{
  RESORT_PEOPLE_ALL_DATA *p_all_people = RESONANCE_RESORT_SV_GetPeopleAllData( p_resort_sv );
  int i, j;

  for( i = 0; i < RESORT_RESIDENT_DATA_NUM; i++ )
  {
    RESORT_RESIDENT_DATA *p_data = RESORT_PEOPLE_ALL_DATA_GetResident( p_all_people, i );
    RESORT_INSTITUTION_DATA *p_ins = RESORT_RESIDENT_DATA_GetInstitution(p_data);
    const RESORT_BINARY_SHOP_DATA *cp_shop_data = RESORT_BINARY_SHOP_SearchDataByData( cp_wk->p_shop, p_data );
    for( j = 0; j < NELEMS(sc_shoppos_restore_tbl); j++ )
    {
      RESORT_INSTITUTION_DATA_SetData( p_ins, sc_shoppos_restore_tbl[j].resort_param, cp_wk->BoxValue[sc_shoppos_restore_tbl[j].editBoxID+SHOPPOS_OFS*i] );
    }
    RESORT_RESIDENT_DATA_SetData( p_data, RESORT_DATA_PARAM_WANT_JOB, cp_wk->BoxValue[EDITBOX_ID_SHOP_ID_00+SHOPPOS_OFS*i] );
    RESORT_RESIDENT_DATA_SetData( p_data, RESORT_DATA_PARAM_TYPE, cp_wk->BoxValue[EDITBOX_ID_SHOP_KIND_00+SHOPPOS_OFS*i] );
  }

  return TRUE;
}
static BOOL ShopPos_PushCallback( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv, u32 boxID )
{
  u32 index   = (boxID-EDITBOX_ID_SHOP_ID_00) / SHOPPOS_OFS;
  u32 baseID  = boxID - index * SHOPPOS_OFS;

  //IDをかえたら、KIND,LV,TYPEがかわりEXPが０になる
  //KINDをかえたら、IDがかわる
  //LVをかえたら、IDがかわる
  //TYPEをかえたら、IDがかわる
  switch( baseID )
  {
  case EDITBOX_ID_SHOP_ID_00:
    {
      const RESORT_BINARY_SHOP_DATA *cp_shop_data = RESORT_BINARY_SHOP_GetData( p_wk->p_shop, p_wk->BoxValue[ boxID ] );
      u16 kind  = RESORT_BINARY_SHOP_DATA_GetData(cp_shop_data, RESORT_BINARY_SHOP_PARAM_SHOP);
      u16 lv    = RESORT_BINARY_SHOP_DATA_GetData(cp_shop_data, RESORT_BINARY_SHOP_PARAM_LV);
      u16 type  = RESORT_BINARY_SHOP_DATA_GetData(cp_shop_data, RESORT_BINARY_SHOP_PARAM_TYPE);
      UpdateBoxInner( p_wk, EDITBOX_ID_SHOP_KIND_00 + index * SHOPPOS_OFS, kind );
      UpdateBoxInner( p_wk, EDITBOX_ID_SHOP_LV_00 + index * SHOPPOS_OFS, lv );
      UpdateBoxInner( p_wk, EDITBOX_ID_SHOP_EXP_00 + index * SHOPPOS_OFS, 0 );
      UpdateBoxInner( p_wk, EDITBOX_ID_SHOP_TYPE_00 + index * SHOPPOS_OFS, type );
    }
    break;
  case EDITBOX_ID_SHOP_KIND_00:
  case EDITBOX_ID_SHOP_LV_00:
  case EDITBOX_ID_SHOP_TYPE_00:
    {
      u16 kind  = p_wk->BoxValue[ EDITBOX_ID_SHOP_KIND_00 + index * SHOPPOS_OFS ];
      u16 lv    = p_wk->BoxValue[ EDITBOX_ID_SHOP_LV_00 + index * SHOPPOS_OFS ];
      u16 type  = p_wk->BoxValue[ EDITBOX_ID_SHOP_TYPE_00 + index * SHOPPOS_OFS ];
      u32 id = RESORT_BINARY_SHOP_SearchShopID( p_wk->p_shop, kind, lv, type );
      UpdateBoxInner( p_wk, EDITBOX_ID_SHOP_ID_00 + index * SHOPPOS_OFS, id );
    }
    break;
  }

  return TRUE;
}

static const struct
{
  EDITBOX_ID  id;
  RESORT_DEBUG_FLAG flag;
}sc_debugflag_to_exitbox[]=
{
  { EDITBOX_ID_FLAG_00, RESORT_DEBUG_FLAG_FORCE_EXCELLENT },
  { EDITBOX_ID_FLAG_01, RESORT_DEBUG_FLAG_EXP_9999 },
  { EDITBOX_ID_FLAG_02, RESORT_DEBUG_FLAG_FORCE_CELEB },
  { EDITBOX_ID_FLAG_03, RESORT_DEBUG_FLAG_FORCE_PRESENT },
  { EDITBOX_ID_FLAG_04, RESORT_DEBUG_FLAG_FORCE_FEVER },
  { EDITBOX_ID_FLAG_05, RESORT_DEBUG_FLAG_FORCE_INIT_COMBO },
  { EDITBOX_ID_FLAG_06, RESORT_DEBUG_FLAG_FORCE_COMBO_MAX },
};
static const struct
{
  EDITBOX_ID  id;
  RESORT_DEBUG_WORK work;
}sc_debugwork_to_exitbox[]=
{
  { EDITBOX_ID_WORK_00, RESORT_DEBUG_WORK_FORCE_SPOT },
  { EDITBOX_ID_WORK_01, RESORT_DEBUG_WORK_FORCE_RND },
};
static void DebugFlag_StoreData( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv )
{ 
  int i;
  for( i = 0; i < NELEMS(sc_debugflag_to_exitbox); i++ )
  {
    p_wk->BoxValue[ sc_debugflag_to_exitbox[i].id ] = RESORT_DEBUG_FLAG_Get( sc_debugflag_to_exitbox[i].flag );
  }
  for( i = 0; i < NELEMS(sc_debugwork_to_exitbox); i++ )
  {
    p_wk->BoxValue[ sc_debugwork_to_exitbox[i].id ] = RESORT_DEBUG_WORK_Get( sc_debugwork_to_exitbox[i].work );
  }
}
static BOOL DebugFlag_ReStoreData( RESONANCE_RESORT_SV *p_resort_sv, const DEBUG_INPUT_WORK *cp_wk )
{
  int i;
  for( i = 0; i < NELEMS(sc_debugflag_to_exitbox); i++ )
  {
    RESORT_DEBUG_FLAG_Set( sc_debugflag_to_exitbox[i].flag, cp_wk->BoxValue[ sc_debugflag_to_exitbox[i].id ] );
  }
  for( i = 0; i < NELEMS(sc_debugwork_to_exitbox); i++ )
  {
    RESORT_DEBUG_WORK_Set( sc_debugwork_to_exitbox[i].work, cp_wk->BoxValue[ sc_debugwork_to_exitbox[i].id ] );
  }

  return TRUE;
}

static const STR_PARAM_DISPLAY *Page_GetStrParamDisplay( STR_PARAM_PAGE_STACK *p_wk )
{
  return &p_wk->cp_now_page->display[ p_wk->page ];
}
static void Page_NextPage( STR_PARAM_PAGE_STACK *p_wk )
{
  p_wk->page++;
  if( p_wk->page >= p_wk->cp_now_page->len )
  {
    p_wk->page = 0;
  }
}
static void Page_PrevPage( STR_PARAM_PAGE_STACK *p_wk )
{
  p_wk->page--;

  if( p_wk->page < 0 )
  {
    p_wk->page  = p_wk->cp_now_page->len-1;
  }
}
static STR_PARAM_PAGE_STACK * Page_PushPage( STR_PARAM_PAGE_STACK *p_wk, const STR_PARAM_PAGE *cp_page )
{
  STR_PARAM_PAGE_STACK *p_stack = GFL_HEAP_AllocClearMemory( HEAPID_WIFIMATCH_DEBUG, sizeof( STR_PARAM_PAGE_STACK ) );
  p_stack->p_prev = p_wk;
  p_stack->cp_now_page = cp_page;

  return p_stack;
}
static STR_PARAM_PAGE_STACK * Page_PopPage( STR_PARAM_PAGE_STACK *p_wk )
{
  GF_ASSERT(p_wk != NULL );
  {
    STR_PARAM_PAGE_STACK *p_prev = p_wk->p_prev;
    GFL_HEAP_FreeMemory( p_wk );
    return p_prev;
  }
}
static void Page_StoreData( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv )
{
  if( p_wk->p_pageData->cp_now_page->StoreData )
  {
    p_wk->p_pageData->cp_now_page->StoreData( p_wk, p_resort_sv );
  }
}
static BOOL Page_ReStoreData( RESONANCE_RESORT_SV *p_resort_sv, const DEBUG_INPUT_WORK *cp_wk )
{
  if( cp_wk->p_pageData->cp_now_page->ReStoreData )
  {
    return cp_wk->p_pageData->cp_now_page->ReStoreData( p_resort_sv, cp_wk );
  }

  return FALSE;
}

static BOOL Page_PushCallback( DEBUG_INPUT_WORK *p_wk, RESONANCE_RESORT_SV *p_resort_sv, u32 boxID )
{
  if(p_wk->p_pageData->cp_now_page->PushCallback )
  {
    return p_wk->p_pageData->cp_now_page->PushCallback( p_wk, p_resort_sv, boxID );
  }

  return FALSE;
}

#endif
